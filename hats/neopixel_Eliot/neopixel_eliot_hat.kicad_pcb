# Repository EPFLXplore/ERC_AV_HW (continued)

## KiCad design Power/ElonMux/ElonMux.kicad_pcb (continued)

Notes on the sheet:
Interfaces
[${#}] ${TITLE}
Power
Sensing
User
Page 5
+VCHARGE
Page 11
Page 10
Page 8
Page 6
Page 7
File: Power - Connector.kicad_sch
Page 9
Page 4
Power - Connectors
+VOUT

Parts:
C801, C802, C803, C804, C805, C806, C807: 100n X7R 50V; C_0402_1005Metric; Manufacturer Part Number UMK105B7104KVHF
C808, C809, C810, C811: 1u X7R 50V; C_0603_1608Metric; Manufacturer Part Number CC0603KRX7R9BB105
D801: VBT3045C-E3_8W; V30DL45BPM3I; Manufacturer Part Number VBT3045C-E3/8W
D802, D803: PMEG4030ER,115; Nexperia_CFP3_SOD-123W; Manufacturer Part Number PMEG4030ER,115
IC801, IC802: LTC7000EMSE#PBF; Manufacturer Part Number LTC7000EMSE#PBF
IC803: TPS3701DDCR; Manufacturer Part Number TPS3701DDCR
LED801, LED802: RED; LED_1206_3216Metric; Manufacturer Part Number SM1206SRC
NT801: NetTie_TS; NetTie-2_SMD_Pad0.5mm
Q801, Q802, Q803, Q804: CSD18540Q5B; TDSON-8-1; Manufacturer Part Number CSD18540Q5B
R801, R809: 0R 1%; R_0603_1608Metric; Manufacturer Part Number RC0603FR-100RL; not fitted
R802, R813, R814, R815: 100R 1% 0.2W; R_0402_1005Metric; Manufacturer Part Number CRCW0402100RFKEDHP
R803, R808: 1k 1% 2W; R_2010_5025Metric; Manufacturer Part Number 35021K0FT
R804, R807: 3R 1%; R_0603_1608Metric; Manufacturer Part Number RK73H1JTTD3R00F
R805, R806: 1m 1% 2W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; Manufacturer Part Number HCS1206FT1L00
R810: 240k 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Manufacturer Part Number ERJ-P06F2403V
R811, R812: 20k5 1%; R_0402_1005Metric; Manufacturer Part Number RK73H1ETTP2052F
R816, R817, R818: 10k 1%; R_0402_1005Metric; Manufacturer Part Number SG73P1EWTTP1002F
R819, R820: 100k 1%; R_0402_1005Metric; Manufacturer Part Number SG73P1EWTTP1002F
TP801: OUTA; TestPoint_Pad_D1.0mm
TP802: TGDN1; TestPoint_Pad_D1.0mm
TP803: OUTB; TestPoint_Pad_D1.0mm
TP804: TGDN2; TestPoint_Pad_D1.0mm
TP805: INX; TestPoint_Pad_D1.0mm
TP806: VCC1; TestPoint_Pad_D1.0mm
TP807: VCC2; TestPoint_Pad_D1.0mm
TP808: +VCHARGE; TestPoint_Pad_D1.0mm
TP809, TP811: GND; TestPoint_Pad_D1.0mm
TP810: +VSUPPLY; TestPoint_Pad_D1.0mm
TP812: VDD; TestPoint_Pad_D1.0mm

Connections:
+VBAT: C801.1, C801.2, C805.1, D801.1, IC802.16 (SNS+), Q803.5 (D), R806.1, R806.2, R814.2, TP810.1; also elsewhere on the board
+VSUPPLY: C802.1, C802.2, C806.1, D801.2, IC801.16 (SNS+), Q801.5 (D), R805.1, R805.2, R810.1, R813.2, TP808.1; also elsewhere on the board
/Project Architecture/MCU - Unit/FAULT1: IC801.5 (~FAULT); also elsewhere on the board
/Project Architecture/MCU - Unit/FAULT2: IC802.5 (~FAULT); also elsewhere on the board
/Project Architecture/MCU - Unit/IMON1: IC801.10 (IMON); also elsewhere on the board
/Project Architecture/MCU - Unit/IMON2: IC802.10 (IMON); also elsewhere on the board
/Project Architecture/Power - Generation/+VOUT: NT801.1, Q802.5 (D), Q804.5 (D); also elsewhere on the board
/Project Architecture/Power - Power Path/BST1: C803.1, IC801.14 (BST)
/Project Architecture/Power - Power Path/BST2: C804.1, IC802.14 (BST)
/Project Architecture/Power - Power Path/GATE1: Q801.4 (G), Q802.4 (G), R801.1, R804.1
/Project Architecture/Power - Power Path/GATE2: Q803.4 (G), Q804.4 (G), R807.1, R809.2
/Project Architecture/Power - Power Path/INX: IC803.3 (INA), IC803.4 (INB), R810.2, R815.1, TP805.1
/Project Architecture/Power - Power Path/ISET1: IC801.9 (ISET), R819.1
/Project Architecture/Power - Power Path/ISET2: IC802.9 (ISET), R820.1
/Project Architecture/Power - Power Path/OUTA: IC801.7 (INP), IC803.1 (OUTA), R811.2, R817.1, TP801.1
/Project Architecture/Power - Power Path/OUTB: IC802.7 (INP), IC803.6 (OUTB), R812.2, R818.1, TP803.1
/Project Architecture/Power - Power Path/SOURCE1: Q801.1 (S), Q801.2 (S), Q801.3 (S), Q802.1 (S), Q802.2 (S), Q802.3 (S), R802.1
/Project Architecture/Power - Power Path/SOURCE2: Q803.1 (S), Q803.2 (S), Q803.3 (S), Q804.1 (S), Q804.2 (S), Q804.3 (S), R808.1
/Project Architecture/Power - Power Path/TGDN1: IC801.11 (TGDN), IC801.12 (TGUP), R801.2, R804.2, TP802.1
/Project Architecture/Power - Power Path/TGDN2: IC802.11 (TGDN), IC802.12 (TGUP), R807.2, R809.1, TP804.1
/Project Architecture/Power - Power Path/TS: C803.2, C804.2, D802.1, D803.1, IC801.13 (TS), IC802.13 (TS), NT801.2
/Project Architecture/Power - Power Path/VCC1: C809.1, IC801.3 (VCC), IC801.6 (TIMER), TP806.1
/Project Architecture/Power - Power Path/VCC2: C811.1, IC802.3 (VCC), IC802.6 (TIMER), TP807.1
/Project Architecture/Power - Power Path/VDD: C807.1, C808.1, C810.1, D801.3, IC801.1 (RUN), IC801.2 (VIN), IC802.1 (RUN), IC802.2 (VIN), IC803.5 (VDD), R811.1, R812.1, TP812.1
GND: C805.2, C806.2, C807.2, C808.2, C809.2, C810.2, C811.2, D802.2, D803.2, IC801.4 (VCCUV), IC801.8 (OVLO), IC801.17 (GND), IC802.4 (VCCUV), IC802.8 (OVLO), IC802.17 (GND), IC803.2 (GND), LED801.1 (K), LED802.1 (K), R816.2, R817.2, R818.2, R819.2, R820.2, TP809.1, TP811.1; also elsewhere on the board
unnamed: IC801.15 (SNS-), R813.1
unnamed: IC802.15 (SNS-), R814.1
unnamed: LED801.2 (A), R803.2
unnamed: LED802.2 (A), R808.2
unnamed: R802.2, R803.1
unnamed: R815.2, R816.1

Notes on the sheet:
PMEG4030EXE: Reverse Voltage: 40V Forward current: 3A Forward voltage: 560mV << 6V ->will conduct before damaging the TS pin.
GND
DESIGN NOTE - Gate Resistors: The CSD18540Q5B has a total gate charge Qg of 41nC (when driven at 10V) Switching Speed: tswitch = Rtotal x Qg where Rtotal = Rgate_ext + Rgate_MOS + Rgate_driver. The LTC7000 gate driver has a pull-down resistance of 1Ω on the TGDN pin. We aim for a switching time of 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
DESIGN NOTE - Optimized gate Resistors: Turn ON: RG = RHI + RGATE + 2xRGI = 2.2 Ohm + RGATE + 2x0.8 Ohm Turn OFF: RG = RLO + RGATE + 2xRGI = 1Ohm + RGATE + 2x0.8 Ohm Source inductance = 1 / (CISS x (2pi x fR)^2) => impossible, fR unknown. -> LT Spice simulation?
DESIGN NOTE: Optionally populate 0 Ohm resistors if need of a faster switching.
Power Path Logic
Drivers Status & Sensing
Power Supply LED
DESIGN NOTE - Delay when switching between loads: Battery Plugged (OUTA low, OUTB high) -> Plugging of Supply: TPS3701: OUTA: low -> high 28.1us OUTB: high -> low 28.1us LTC7000 TGDN1 low -> high worst case: 70ns + 90ns = 160ns LTC7000 TGDN2 high -> low worst case: 70ns + 40ns = 110ns CSD18540Q5B: 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
Drivers
Test Points
VBT3045C-E3 Reverse Voltage: 45V Forward current: 15A per diode, 30A total. Forward voltage: 390mV @ 15A
Battery LED
DESIGN NOTE - LTC7000 connections: RUN: Connect to Vin to ensure normal operation of the IC TIMER: Connect to VCC to disable the auto-restart feature. IMON: Can be left floating if no need of current monitoring. The voltage on this pin with respect to GND represents the voltage across the sense res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
[${#}] ${TITLE}
Dual Power Path Multiplexer
DESIGN NOTE - Power Path LEDs: SM1206SRC has a typical luminous intensity of 28 mcd (millicandela) @ 20mA. Typ. Vf = 1.85V,, Max Vf = 2.3V R = 1100 Ohm Min: If = (24V - 2.3V)/1100 ≈ 20 mA P = 2.3V×20mA ≈ 46 mW < 69 mW (max rating) Max: If = (36V - 1.85V)/1100 ≈ 31 mA P = 1.85V×31mA ≈ 57 mW < 69 mW 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
Filtered Power Rails
DESIGN NOTE - Voltage divider: INA/INB @ VSUPPLY = 36V: 36V x 10k1 /(10k1 + 240k) = 1.454V INA/INB @ VSUPPLY = 10V: 10V x 10k1 /(10k1 + 240k) = 404mV 10 <= VSUPPLY <= 36V: -> INA/INB > VIT (400mV) -> OUTA high -> OUTB low 0 <= VSUPPLY < 10V: -> INA/INB < VIT (400mV) -> OUTA low -> OUTB high
CSD18540Q5B 60 V N-Channel NexFET™ Power MOSFET: VDS(Drain-Source Breakdown Voltage) = 60V RDS(on) (Drain-Source On-Resistance) = 2.6mΩ @ 4.5V VGS ID - Continuous Drain Current = 29A VGS(th) - Gate-Source Threshold Voltage = 1.9V VGS - Gate-Source Voltage = ±20V
DESIGN NOTE - Pull-up/ Divider Resistors: OUTA/B are open drain, so this design ensure a logic signal between 3.4V (10V input) and 12.4V (36V input). The INP pin of LTC7000 requires at least 2V but less than 15V to turn on the FETs, making this design a proper fit. 3V3 is not used for the pull up, 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
Inspiration from TI Design: TIDA-00394 Dual Power Path Multiplexer Reference Design.
External Gate Resistor Design Guide for Gate Drivers

Parts:
D501, D502, D503, D504: SMBJ30CA; DIOM5436X244N; Manufacturer Part Number SMBJ30CA
J501, J502, J503, J504: XT60PW-M; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal; Manufacturer Part Number XT60PW-M

Connections:
+VBAT: D503.1, J503.2; also elsewhere on the board
+VCHARGE: D502.1, J502.2; also elsewhere on the board
+VSUPPLY: D501.1, J501.2; also elsewhere on the board
/Project Architecture/Power - Generation/+VOUT: D504.1, J504.2; also elsewhere on the board
GND: D501.2, D502.2, D503.2, D504.2, J501.1, J501.3 (MP1), J501.4 (MP2), J502.1, J502.3 (MP1), J502.4 (MP2), J503.1, J503.3 (MP1), J503.4 (MP2), J504.1, J504.3 (MP1), J504.4 (MP2); also elsewhere on the board

Notes on the sheet:
SMBJ30A: Reverse Stand off voltage: 30.0V Min Breakdown Voltage: 33.30V Max Breakdown Voltage: 36.80V Max Clamping Voltage: 48.40V Peak Pulse Power Dissipation: 600W Peak Forward Surge Currents: 100A
DESIGN NOTE: Do not exceed the absolute maximum input voltage rating of 36V.
LAYOUT NOTE: Place TVS diode near input power connectors.
Power Output Connector to Battery, TVS Diode
Power Input Connector from Battery, TVS Diode
Power Output Connector to rover, TVS Diode
[${#}] ${TITLE}
Power Input Connector from Power Supply, TVS Diode
DESIGN NOTE: TVS (Transient Voltage Suppresion) used to protect circuits from voltage spikes by clamping high voltages to a safe level.
Inspired by Amulet controller Schematics by Vincent Nguyen

Parts:
C601, C602: 1u X7R 50V; C_0603_1608Metric; Manufacturer Part Number CC0603KRX7R9BB105
C603, C608, C610: 4u7 X7R 50V; C_0805_2012Metric; Manufacturer Part Number CGA4J1X7R1H475K125AC
C604, C609: 100n X7R 50V; C_0402_1005Metric; Manufacturer Part Number UMK105B7104KVHF
C605: 10p X7R 25V; C_0603_1608Metric; Manufacturer Part Number 06033C100KAT2A
C606, C607: 22u X5R 50V; C_0603_1608Metric; Manufacturer Part Number GRT188R61A226ME13D
IC601: LTC3126IUFD#PBF; LTC3126EUFD; Manufacturer Part Number LTC3126IUFD#PBF
L601: 4u7; L_0805_2012Metric; Manufacturer Part Number IMC0805ER4R7J01
LED601: RED; LED_1206_3216Metric; Manufacturer Part Number SM1206SRC
R601: 56R 1% 0.5W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Manufacturer Part Number SG73P2ATTD56R0F
R602, R603, R604, R605: 10k 1%; R_0402_1005Metric; Manufacturer Part Number SG73P1EWTTP1002F
R606: 909k 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Manufacturer Part Number ERJ-P06F9093V
R607: 301k 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Manufacturer Part Number RK73H2ATTD3013F
R608: 44k2 1%; R_0402_1005Metric; Manufacturer Part Number ERJ-2RKF4422X
TP601: +VOUT; TestPoint_Pad_D1.0mm
TP602: +VBUS; TestPoint_Pad_D1.0mm
TP603: VIN2; TestPoint_Pad_D1.0mm
TP604, TP605: GND; TestPoint_Pad_D1.0mm

Connections:
+3V3: C605.1, C606.2, C607.2, IC601.4 (EXTVCC), L601.2, R601.1, R602.1, R603.1, R604.1, R605.1, R606.1, TP603.1; also elsewhere on the board
+VBUS: C608.1, C609.1, IC601.13 (PVIN2), IC601.26 (VIN2), TP602.1; also elsewhere on the board
/Project Architecture/MCU - Unit/PGOOD: IC601.11 (PGOOD), R605.2; also elsewhere on the board
/Project Architecture/MCU - Unit/PRIORITY: IC601.12 (~PRIORITY), R602.2; also elsewhere on the board
/Project Architecture/MCU - Unit/VALID1: IC601.28 (~VALID1), R603.2; also elsewhere on the board
/Project Architecture/MCU - Unit/VALID2: IC601.1 (~VALID2), R604.2; also elsewhere on the board
/Project Architecture/Power - Generation/+VOUT: C603.1, C604.1, IC601.24 (PVIN1), IC601.25 (VIN1), TP601.1; also elsewhere on the board
/Project Architecture/Power - Generation/FB: C605.2, IC601.9 (FB), R606.2, R607.1
/Project Architecture/Power - Generation/SW1_3V3: IC601.17 (SW_1), IC601.20 (SW_2), L601.1
GND: C603.2, C604.2, C606.1, C607.1, C608.2, C609.2, C610.2, IC601.5 (VSET1), IC601.6 (VSET2), IC601.8 (GND), IC601.18 (PGND_1), IC601.19 (PGND_2), IC601.23 (DIODE), IC601.27 (PWM/SYNC), IC601.29 (PGND_3), LED601.1 (K), R607.2, R608.2, TP604.1, TP605.1; also elsewhere on the board
unnamed: C601.2, IC601.22 (BST1)
unnamed: C602.2, IC601.15 (BST2)
unnamed: C601.1, IC601.21 (COM1)
unnamed: C602.1, IC601.16 (COM2)
unnamed: C610.1, IC601.2 (VCC), IC601.3 (PVCC), IC601.7 (VREF), IC601.14 (ENA)
unnamed: IC601.10 (RT), R608.1
unnamed: LED601.2 (A), R601.2

Notes on the sheet:
DESIGN NOTE: Higher switching frequency like 2Mhz induce more switching losses, but smaller inductance meaning smaller PCB footprint.
Test Points
LAYOUT NOTE: Place each components as close as possible to minimize size of: - input loop - output loop - power switching loop (important) - rectifier loop (important)
GND
Filtered Power Rails
DESIGN NOTE - 3V3 STATUS LED SM1206SRC has a typical luminous intensity of 28mcd (millicandela) @ 20 mA. Typ. Vf = 1.85V Max Vf = 2.3V Typ. If = (3.3V - 1.85V)/56hm ≈ 26 mA Max. If = (3.3V - 2.3V)/56hm ≈ 18 mA P = 1.85V×26mA ≈ 48 mW < 69 mW (max rating)
[${#}] ${TITLE}
DESIGN NOTE - LTC3126 status pins: PRIORITY, VALID1, VALID2 & PGOOD are open drain -> pull-up resistors. PRIORITY is driven low when the buck converter is currently using the priority input, VIN1. VALID1 is driven low when VIN1 is above the internal fixed UVLO threshold (2.54V) VALID2 is driven low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
DESIGN NOTE: DIODE to GND activate priority mode. VIN1 (VSUPPLY) will be used first.
3.3V, 750kHz synchronous step-down regulator with no-loss input PowerPath
DESIGN NOTE: 87% EFFICIENCY, VIN=24V, 1A LOAD 330mV DROPOUT AT 1A LOAD 660mV DROPOUT AT 2A LOAD VOUT 2.5A max
LTC3126 Datasheet p.24
