# Repository EPFLXplore/ERC_AV_HW (continued)

## KiCad design terminal_block/terminal_block/Old versions/V4/terminal_block.kicad_pcb

Parts:
J1, J2, J3, J4, J5, J6, J7, J8, J11, J12, J13, J14, J16, J17, J19, J20, J21, J22, J24, J25, J26, J28, J30, J31: XT60F; AMASS_XT60-F_1x02_P7.20mm_Vertical
J9: XT60F - Horizontal; AMASS_XT30UPB-M_1x02_P5.0mm_Vertical
J33: XT30F; AMASS_XT30UPB-F_1x02_P5.0mm_Vertical
J34, J35, J36, J37, J41, J42, J43, J44, J45: XT30F; AMASS_XT30UPB-M_1x02_P5.0mm_Vertical

Connections:
+5V: J33.2, J34.2, J35.2, J36.2, J37.2, J41.2, J42.2, J43.2, J44.2, J45.2
+12V: J19.2, J20.2, J30.2, J31.2
+15V: J13.2, J14.2, J16.2, J17.2
+24V: J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2
+BATT: J11.2, J12.2, J21.2, J22.2, J24.2, J25.2, J26.2, J28.2
GND: J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J11.1, J12.1, J13.1, J14.1, J16.1, J17.1, J19.1, J20.1, J21.1, J22.1, J24.1, J25.1, J26.1, J28.1, J30.1, J31.1, J33.1, J34.1, J35.1, J36.1, J37.1, J41.1, J42.1, J43.1, J44.1, J45.1

Notes on the sheet:
15V
Vbat
24V
12V

Board: 2 copper layers, 100.0 x 97.5 mm, 38 parts (0 on the bottom side), 6 nets.

Other parts of the board:
H2, H2#2, H2#3, H2#4: M3; MountingHole_3.2mm_M3_Pad_Via

## KiCad design terminal_block/terminal_block/terminal_block.kicad_pcb

Board: 2 copper layers, 117.5 x 115.0 mm, 46 parts (0 on the bottom side), 6 nets.

Parts:
H2, H2#2, H2#3, H2#4: M3; MountingHole_3.2mm_M3_Pad_Via
J1, J2, J3, J4, J5, J6, J7, J8, J11, J12, J13, J14, J16, J17, J19, J20, J21, J22, J24, J25, J26, J28, J30, J31: XT60F; AMASS_XT60-F_1x02_P7.20mm_Vertical
J9, J10, J15, J18, J23: XT60F; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J27, J29, J32, J33, J38: XT60M; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J34, J35, J36, J37, J41, J42, J43, J45: XT30F; AMASS_XT30UPB-M_1x02_P5.0mm_Vertical

Connections:
+5V: J23.2, J34.2, J35.2, J36.2, J37.2, J38.2, J41.2, J42.2, J43.2, J45.2
+12V: J15.2, J19.2, J20.2, J30.2, J31.2, J33.2
+15V: J13.2, J14.2, J16.2, J17.2, J18.2, J32.2
+24V: J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J10.2, J29.2
+BATT: J9.2, J11.2, J12.2, J21.2, J22.2, J24.2, J25.2, J26.2, J27.2, J28.2
GND: J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, J17.1, J18.1, J19.1, J20.1, J21.1, J22.1, J23.1, J24.1, J25.1, J26.1, J27.1, J28.1, J29.1, J30.1, J31.1, J32.1, J33.1, J34.1, J35.1, J36.1, J37.1, J38.1, J41.1, J42.1, J43.1, J45.1

## Commit log (part)

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2022-09-19 Added USB-UART bridge
2022-09-19 Changed usb uart activity led power net
2022-09-20 Added dual channel switching regulator. TODO: add reverse polarity protection on voltage input
2022-09-22 Power and ESP32 moved to daugtherboards
2022-09-22 Edited page settings. moved blocks around
2022-09-22 Added titles and plots
2022-09-29 Routed most of the digital signals
2022-10-02 updated paths
2022-10-02 Added orion lib submodule
2022-10-02 Updated power pin type
2022-10-02 Finished routing. Need to add logos
2022-10-02 Updated lib
2022-10-02 Added orion logo
2022-10-02 Changed page settings, added dimensions
2022-10-02 Added plots, gerbers and removed unused schematic
2022-10-02 Updated page number
2022-10-02 Added test pads for usart1
2022-10-03 Updated uart
2022-10-03 Replaces polygon pours with keepout zones for DRC check
2022-10-04 Replaced timer 3 with timer 8 (timer 8 is an advanced control timer, dead time might be useful for h-bridge)
2022-10-04 Replaced timer 3 with timer 8
2022-10-04 Changed logo font
2022-10-04 Fixed typo in value, updated bom
2022-10-04 Added spacers for hats in bom
2022-10-05 Added symbol and footprint tables
2022-10-05 Added back footprint and symbol tables
2022-10-06 Added teardrops
2022-10-07 Changed schematics titles and comments
2022-10-07 Changed denominations of some resistors
2022-10-07 Revert "Changed denominations of some resistors"
    This reverts commit 4a6d0156b4e271dc6a5a0d20dbf2fef468595968.
2022-10-07 Added ground symbol after deleting it
2022-10-08 Revert "Removed all files on master"
    This reverts commit ff7e8f853d3abdc9aa0abdacf783b4a9b34c6294.
2022-10-08 Cleaned file
2022-10-08 Changed footprint for the motor choke inductors
2022-10-08 Cleaned master branch
2022-10-08 Updated orion lib
2022-10-08 Added pullup resistor on qspi N_CS
2022-10-08 Moved reference designator
2022-10-11 Added all component references and footprints, added design rules/stackup
2022-10-12 Partially routed power
2022-10-14 Finished routing power supply board
2022-10-14 Rounded tracks, added teardrops
2022-10-14 Added BOM, pdf and changed page settings
2022-10-14 Finished routing orion power supply
2022-10-15 Changed things here and there and tracing is pretty much finished for the CAN interface
2022-10-16 Updated values/bom
2022-10-16 Added debug interface and fixed bom
2022-10-17 Added overall bom (for 5x orion, 5x power and 1x debug)
2022-10-19 Adjusted input power fill shape
2022-10-19 Slightly adjusted fill zones
2022-10-21 Current tracing and a lot of things changed. I can't remember what
2022-10-21 Changed sponsors, didn't really get what I was told
2022-11-01 Added orion rev2 (no teardrops/rounded traces)
2022-11-01 Regenerated step file
2022-11-02 Added support for CAN and RS485 (hats should be designed for top right and bottom left)
2022-11-02 Changed order of USART2 RX, TX, RTS pins on hat for easier routing of RS485 transceiver
2022-11-02 Updated step file
2022-11-05 Changed pin order for second I2C to be delocalizable
2022-11-06 Added testing jig hat
2022-11-07 Updated testing jig, added sym and fp table back in power module
2022-11-19 Updated BOMs and added ST-LINK adapter
2022-11-20 Updated localization files
2022-11-20 Added DRV
2022-12-02 Added voltmeter board
2022-12-02 Updated steps
2022-12-06 moved dimensions to user comment layer
2022-12-22 Added voltmeter v2
2022-12-22 Matched length of USB differential pair
2023-01-13 Changed ESD chips, still need to route
2023-01-31 Changed power supply and small adjustments added
2023-02-01 Checkpoint rev 1.0
2023-02-04 Rev 1.2 - Ready for review
2023-03-02 Minor changes
2023-03-21 Added second version of nav controller interface
2023-03-22 Added v2 of nav interface board
2023-03-23 fixed position
2023-03-24 Added v3 of the board
2023-03-27 Updated Nav can board Mk2
2023-03-28 Updatede nav_controller_interface_v2
2023-03-28 Corrected CANL line not connected to switch for Driving
2023-03-31 Changed placement of CAN connectors
2023-03-31 finished routing
2023-04-01 Ported to kicad 7
2023-04-01 Finished v3
2023-04-01 Fixed pinout
2023-04-01 Removed obsolete files
2023-04-02 added vias
2023-04-03 Fixed silkscreen
2023-04-03 Minor correction
2023-04-03 Minor modifications
2023-04-04 Minor corrections
2023-04-12 Can't remember what I did. Probably not important
2023-04-17 Latest version of the ESC. Better current and voltage measurement. USB 2.0/UART switch added. Reworked the entire layout. Corrected the schematics. All in all, this is the ultimate prototyping versio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
2023-04-17 Finished v3 without headers for jst GH
2023-04-17 Minor changes.
2023-04-24 Updated schematic
2023-05-17 Added blender 3dpcb file
2023-06-17 Finished Heisenberg Hat
2023-06-24 various changes to jetson hat
2023-06-26 Added CanOrion
2023-06-26 Changed layout of canorion
2023-07-02 Finished routing orion v4 with new ESD
2023-07-02 Changed fonts and corrected pinout error on common mode choke
2023-07-02 Updated lib and added teardrops
2023-07-02 Updated schematics, bom and addes template sheet
2023-07-02 Updated plot
2023-07-02 Moved author to comment 4
2023-07-03 Better routing for LDO, added spacer 3d model and hat connector in BOM
2023-07-03 Added .step file, minor routing changes
2023-07-03 Softer turn for CAN lines
2023-07-08 Added GPIOs for CAN silent mode and 3v3 power monitoring. Fixed CANH/CANL pinout
2023-07-09 Meissa v2 routed
2023-07-10 Ignore order sheets
2023-07-12 Almost finished routing voltmeter
2023-07-12 Finished routing voltmeter, still need to add bom
2023-07-13 Wrong pinout for NMOS 3V3 selection...
2023-07-14 Added spectrophotometer interface pcb
2023-07-15 Added teardrops and reduced analog signals trace width
2023-07-15 Removed uncessary ffiles
2023-07-15 Deleted unused files
2023-07-15 Added level shifter hat
2023-07-15 Removed unused file
2023-07-15 Added empty ads1234 project
2023-07-16 Added mass sensor
2023-07-16 Added load cell connector interface
2023-07-16 RS485 transceiver 2
2023-07-17 Added RS485 Hat
2023-07-17 A small service
2023-07-20 Added IMU hat
2023-07-27 Adjusted BOMs, verified sourcing of parts
2023-07-27 Generated step for load cell interface
2023-08-09 Added jetson hat (temporary) to be modified
2023-08-10 Added COTS Led board
2023-08-10 small correction on smoled
2023-08-12 Led ready for prototyping, awaiting clean up of schematic for austists and cringe redditors appreciation
2023-08-13 updated voltmeter gerbers:
2023-08-13 added COTS rp2040 LED hat
2023-09-30 added untested led hat
2023-10-01 commit for tutorial
2023-11-03 Moved files for cleaner git
2023-11-03 again
2023-11-04 Mutiplexer to control
2023-11-05 name
2023-11-11 Realized I made a labeling error on the D+ and D- lines. Corrected now.
2023-11-15 not much changed but I am going to test stuff and if I break everything I want to have a backup
2023-11-24 Nav board routing completed
2023-11-26 v2 of Neopixel hat
2023-11-26 fixed some wiring
2023-11-30 Lets hope third time is the charm :)
2023-12-21 Nav board completed
2023-12-21 eliminated svg file
2023-12-21 Few fix
2024-02-04 Updated jetson_hat
    Replaced the "jetson_hat" folder by the one I had locally with the schematic and routing of the new design.
2024-02-06 Uploaded the new version
    Hat V3, completely rerouted from V2
2024-02-06 Removed some old files
2024-02-09 Routing Neopixel
2024-02-09 Added to silkscreen neopixel
2024-02-10 Draft 2 - Neopixel routing
2024-02-11 Adding SCL address to ADS1115 potentiometer
2024-02-12 Draft 3 - Neopixel routing
2024-02-12 Connector correctly aligned
2024-02-13 Draft 5 - Neopixel Routing
2024-02-15 Draft 6 - Neopixel Routing
2024-02-15 Fixed PCB constrained for command
2024-02-15 Edited via size for cost reducing + created manuf files
2024-02-22 Added component list
2024-03-19 fixing error oops
2024-03-19 updated++
2024-04-22 I changed the 4.7uF termination capacitance for the 4.7nF Vincent told me to change on the Jetson Hat 4 months ago
2024-04-22 gitignore ther .lck
2024-05-07 New voltmeter
2024-05-07 Voltmeter with changes
2024-05-09 updated power trace
2024-05-09 built the zones
2024-05-13 Meriem voltmeter
2024-07-11 New Jetson Hat
2024-07-11 Minor routing ajustment and silkscreen error correction
2024-07-11 Forgot to replot the manufacturing files. Now done.
2024-07-15 Neopixel v2
2024-07-16 Added the links to the BOM
2024-07-22 neopixel update pour Farouk
2024-07-24 Neopixel v2.1
2024-07-24 New schematics for the mass sensor, see : ADS1234_mass_sensor/ADS13M08IPAG
2024-07-27 Neopixel v2.2 with BOM and Gerber/Drill files
2024-08-02 Moved a hole 2 mm so its cleaner and plotted the gerbers/drill files
2024-08-02 Terminal Block PCB V1
2024-08-02 Terminal Block PCB V2, added vias and fixed symetry issue
2024-08-16 Terminal Block V3, not finished, need to check some things tomorrow
2024-08-18 terminal block routing finished, some checks tomorrow and its done
2024-08-18 terminal block finished
2024-09-16 First push of 2024-2025
2024-10-02 added FW
2024-10-05 start of revision, changed the i2c to UART and usb micro to usb c
2024-10-09 1st revision done, waiting for comments
2024-10-12 Geode starting architecture setup
2024-10-14 Introduction of the Charge Manager
2024-10-14 Added .DS_Store in .gitignore
2024-10-14 Fixed page numbering
2024-10-15 fixed repo
2024-10-15 wago 2.0
2024-10-15 First review changes, renamed project
2024-10-16 Added more fede recommandations
2024-10-18 gerbers power hat
2024-10-18 Added new_imu and new_imu_hat
    New folders containing the new IMU project files for both boards
2024-10-19 new_imuv2 and new_imu_hatv2
    Changes to the new IMU boards after Eliot's review
2024-10-19 Corrections after 2nd Review
    More changes after clarifications from Eliot. Changed the voltages on the CAN-I2C Bridge to optimize it and lessen power consumption and added extra connectors to split CAN and INT pins as they need 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
2024-10-19 new_imu minor corrections
    Minor corrections to layout
2024-10-19 Minor corrections
    Layout needed some corrections
2024-10-19 Delete hats/new_imuv2 directory
    Confusing copy deleted
2024-10-19 IMU v3 review Ismail
2024-10-19 IMU Ismail v3
2024-10-20 Ismail IMU v4
    Minor changes to the IMU power delivery, only sending 5v to the board which is regulated down to 3v3 with an LDO to make the connectors smaller and also brought the DRDY signal for the magnetometer i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
2024-10-20 Ismail IMU v4.1
    Added status LED to the LDO
2024-10-21 Rough layout
2024-10-23 fixing git
2024-10-24 Updated new imu schematics and started layout and routing
2024-10-25 Ready for layout review
2024-10-25 new schematic with stm32 (before rev)
2024-10-27 Implemented some layout review by Fede
2024-10-27 Implemented more fede recommandations
2024-10-29 More ameliorations
2024-10-29 IMU v2 after review, IMU is done HAT still isn't done and is WIP
2024-10-30 IMU v3 boards, DONE
2024-11-08 final version before new comnnectors
2024-11-08 hat with STM32F411 more flash
2024-11-09 Fixed insulation and 1/2 connector
2024-11-12 tests
2024-11-12 placements for IMU
2024-11-17 IMU Layout and routing fixes
2024-11-20 IMU tweaks
2024-11-21 IMU changes to ground routing
2024-11-25 1st layout
2024-11-25 Refreshed tear drops
2024-11-26 Nothing to declare
2024-11-27 IMU DRC fixes
2024-11-29 second layout
2024-11-30 IMU final touches
2024-12-07 1st routing
2024-12-09 Corrected some things, still need top check impedance control
2024-12-10 changed the capas to bigger ones as Ismail did before
2024-12-11 live changes
2024-12-11 validated pcb
2024-12-12 Pedro review
2024-12-14 Added Images
2024-12-16 Implemented BQ battery charger
2024-12-17 More corrections and adjustments
2024-12-18 changed R size
2024-12-18 files du hat
2024-12-18 gerbers for both
2024-12-18 Generated manufacturing files
2024-12-18 Fixed impedance control and generated GERBERS Lumos
2024-12-20 Add example
2024-12-22 Re-rooted charger area for reduced EMI and added 24V FAN soldering holes
2025-01-02 fixed mask
2025-01-23 Changed inductors footprints, cleaned copper fills areas, improved silkscreen
2025-01-25 Added PDF and blender file
2025-01-26 Rounded USB lines, improved silkscreen
2025-01-27 Added I2C adress on PCB and schematic
2025-02-22 Minor touches after order
