# Repository EPFLXplore/ERC_AV_HW (continued)

## KiCad design Power/ElonMux/ElonMux.kicad_pcb (continued)

Parts:
C701, C712, C713, C714, C715, C717, C718: 100n X7R 50V; C_0402_1005Metric; Manufacturer Part Number UMK105B7104KVHF
C702, C703, C704, C711: 27u 63V; CP_Elec_8x6.7; Manufacturer Part Number A768KE276M1JLAE054
C705, C706, C707, C708, C709, C710: 10u X7R 50V; C_1206_3216Metric; Manufacturer Part Number CL31B106KBHNNNE
C716: 10n X7R 50V; C_0402_1005Metric; Manufacturer Part Number 04025C103JAT2A
C719, C720, C722: 22u X5R 50V; C_0603_1608Metric; Manufacturer Part Number GRT188R61A226ME13D
C721: 220p X7R 50V; C_0402_1005Metric; Manufacturer Part Number 04025C221JAT2A
L701: 1u; 74439323010; Manufacturer Part Number 74439323010
LED701: RED; LED_1206_3216Metric; Manufacturer Part Number SM1206SRC
Q701, Q702, Q703, Q704: CSD18540Q5B; TDSON-8-1; Manufacturer Part Number CSD18540Q5B
R701: 7m 1% 1W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Manufacturer Part Number WSLP08057L000FEA18
R702, R703, R714, R715: 3R 1%; R_0603_1608Metric; Manufacturer Part Number RK73H1JTTD3R00F
R704, R706: 130k 1%; R_0402_1005Metric; Manufacturer Part Number ERJ-2RKF1303X
R705: 75k 1%; R_0402_1005Metric; Manufacturer Part Number ERJ-PA2F7502X
R707: 1k 1% 2W; R_2010_5025Metric; Manufacturer Part Number 35021K0FT
R708, R709, R716, R717: 0R 1%; R_0603_1608Metric; Manufacturer Part Number RC0603FR-100RL; not fitted
R710, R721: 10k 1%; R_0402_1005Metric; Manufacturer Part Number SG73P1EWTTP1002F
R711, R713: 5k6 1%; R_0402_1005Metric; Manufacturer Part Number RCS04025K60FKED
R712: 1m 1% 2W; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder; Manufacturer Part Number HCS1206FT1L00
R718, R719: 10R 1%; R_0402_1005Metric; Manufacturer Part Number RK73H1ETTPL10R0F
R720: 44k2 1%; R_0402_1005Metric; Manufacturer Part Number ERJ-2RKF4422X
R722: 20k5 1%; R_0402_1005Metric; Manufacturer Part Number RK73H1ETTP2052F
R723: 56k 1%; R_0402_1005Metric; Manufacturer Part Number RCS040256K0FKED
TP701: +VCHARGE; TestPoint_Pad_D1.0mm
TP702: +VSUPPLY; TestPoint_Pad_D1.0mm
TP703: HO1; TestPoint_Pad_D1.0mm
TP704: HO2; TestPoint_Pad_D1.0mm
TP705: LO1; TestPoint_Pad_D1.0mm
TP706: LO2; TestPoint_Pad_D1.0mm
TP707: SW1; TestPoint_Pad_D1.0mm
TP708: SW2; TestPoint_Pad_D1.0mm
TP709, TP710: GND; TestPoint_Pad_D1.0mm
U701: LM51772RHAR; Manufacturer Part Number LM51772RHAR

Connections:
+VCHARGE: C701.1, C701.2, C706.2, C707.2, C708.2, C709.2, C710.2, C711.1, Q702.5 (D), R701.1, R701.2, R704.1, R707.1, TP701.1, U701.18 (VOUT), U701.19 (ISNSN), U701.20 (ISNSP); also elsewhere on the board
+VSUPPLY: C702.1, C703.1, C704.1, C705.2, C717.2, C718.2, Q701.5 (D), R705.1, R706.1, TP702.1, U701.36 (VIN), U701.38 (nRST), U701.40 (BIAS); also elsewhere on the board
/Project Architecture/MCU - Unit/CHARGER_STATUS: U701.11 (nFLT/nINT); also elsewhere on the board
/Project Architecture/MCU - Unit/SCL: U701.6 (SCL/CFG4); also elsewhere on the board
/Project Architecture/MCU - Unit/SDA: U701.5 (SDA/CFG3); also elsewhere on the board
/Project Architecture/Power - Charger/CDC: R720.1, U701.10 (CDC)
/Project Architecture/Power - Charger/CFG2: R722.1, U701.8 (CFG2)
/Project Architecture/Power - Charger/COMP: C716.2, C721.2, U701.13 (COMP)
/Project Architecture/Power - Charger/DRV1: U701.35 (DRV1)
/Project Architecture/Power - Charger/EN/UVLO: C712.2, R705.2, R710.1, U701.37 (EN/UVLO)
/Project Architecture/Power - Charger/FB/SEL_intFB: R704.2, R713.1, U701.14 (FB/SEL_intFB)
/Project Architecture/Power - Charger/HB1: C714.2, U701.25 (HB1)
/Project Architecture/Power - Charger/HB2: C715.2, U701.31 (HB2)
/Project Architecture/Power - Charger/HO1: R702.2, R708.2, TP703.1, U701.24 (HO1)
/Project Architecture/Power - Charger/HO2: R703.2, R709.1, TP704.1, U701.32 (HO2)
/Project Architecture/Power - Charger/ILIMCOMP/ISET: C720.2, U701.16 (ILIMCOMP/ISET), U701.29 (VCC2)
/Project Architecture/Power - Charger/LO1: R714.1, R716.2, TP705.1, U701.27 (LO1)
/Project Architecture/Power - Charger/LO2: R715.2, R717.1, TP706.1, U701.30 (LO2)
/Project Architecture/Power - Charger/RT: R723.1, U701.12 (RT)
/Project Architecture/Power - Charger/SS/ATRK: C722.2, U701.2 (SS/ATRK)
/Project Architecture/Power - Charger/SW1: C714.1, Q701.1 (S), Q701.2 (S), Q701.3 (S), Q703.5 (D), R712.1, R718.2, TP707.1, U701.23 (SW1)
/Project Architecture/Power - Charger/SW2: C715.1, L701.2, Q702.1 (S), Q702.2 (S), Q702.3 (S), Q704.5 (D), TP708.1, U701.33 (SW2)
/Project Architecture/Power - Charger/VCC1: C719.2, U701.1 (VCC1)
/Project Architecture/Power - Charger/VIN-FB: R706.2, R711.1, U701.15 (VIN-FB)
/Project Architecture/Power - Charger/shunt_bridge-: L701.1, R712.2, R719.2
GND: C702.2, C703.2, C704.2, C705.1, C706.1, C707.1, C708.1, C709.1, C710.1, C711.2, C712.1, C717.1, C718.1, C719.1, C720.1, C721.1, C722.1, LED701.1 (K), Q703.1 (S), Q703.2 (S), Q703.3 (S), Q704.1 (S), Q704.2 (S), Q704.3 (S), R710.2, R711.2, R713.2, R720.2, R721.2, R722.2, R723.2, TP709.1, TP710.1, U701.3 (SYNC), U701.4 (DTRK), U701.7 (MODE), U701.9 (ADDR/SLOPE(CFG1)), U701.17 (AGND), U701.28 (PGND), U701.41 (GND); also elsewhere on the board
unnamed: C716.1, R721.1
unnamed: LED701.2 (A), R707.2
unnamed: Q701.4 (G), R702.1, R708.1
unnamed: Q702.4 (G), R703.1, R709.2
unnamed: Q703.4 (G), R714.2, R716.1
unnamed: Q704.4 (G), R715.1, R717.2
unnamed: C713.2, R718.1, U701.22 (CSA)
unnamed: C713.1, R719.1, U701.21 (CSB)

Notes on the sheet:
1V - 55 V
Bridge Driver
Compensation network that stabilizes the regulator's voltage loop. Balance betwwen BOM size and performance.
GND
DESIGN NOTE - Charging LED: SM1206SRC has a typical luminous intensity of 28mcd (millicandela) @ 20 mA. Typ. Vf = 1.85V Max Vf = 2.3V R = 1000 Ohm Min charge: Typ. If = (21V - 1.85V)/1000hm ≈ 19 mA Max. If = (21V - 2.3V)/1000hm ≈ 19 mA Max charge: Typ. If = (29V - 1.85V)/1000hm ≈ 27 mA Max. If = (2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
DESIGN NOTE: LED might burn if more than 32V are applied to the battery
DESIGN NOTE - Gate resistors: Typical MOSFET switching time for 500kHz Buck-Boost: 50ns Internal LM51772 gate resistors: High-side pull-up (HO1, HO2): 1.5 ohms. High-side pull-down (HO1, HO2): 0.8 ohms. Low-side pull-up (LO1, LO2): 1.8 ohms. Low-side pull-down(LO1, LO2): 0.9 ohms​. Switching Speed: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
Current limit block: DISABLED -> done with I2C
LM51772 circuit design settings:
DRV1 can be used as as a high-voltage driver, to control an external FET for input/output disconnect or reverse polarity protection.
DESIGN NOTE - Switching frequency: With the RT resistor being set to 56k Ohm, we espect a switching frequency of around 600kHz.
Nominal Input:
Input voltage:
Possible output voltage:
DESIGN NOTE: Cout is composed of 5 smaller capacitors in parallel to provide better ripple current handling and lower ESR (Equivalent Series Resistance) compared to a large capacitor.
Test Points
DESIGN NOTE: CAUTION, always respect the battery rated voltage and current.
VT-(UVLO) = 1.2V -> @10V, VUVLO = 1.18V -> disabled -> above 10V, VUVLO > 1.2V -> enabled
Nominal Output:
24V
[${#}] ${TITLE}
25V
Cable drop compensation
Max Output current:
SOFTSTART: ENABLED
Filtered Power Rails
Those feedback resistors networks need to be the same to enable the Programmable Conduction Mode (PCM). This mode uses the device's internal charge pumps to keep the High side MOS ON when specific input/output voltages requirements are met. VREF = 1V Vout = 1V X (130k + 5k6) / 5k6 = 24.21V This is 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
CSD18563Q5A 60 V N-Channel NexFET™ Power MOSFET: VDS(Drain-Source Breakdown Voltage) = 60V Maximum voltage the MOSFET can handle between the drain and source when it's off (not conducting). RDS(on) (Drain-Source On-Resistance) = 6.8 mΩ This is the resistance between the drain and source when the MO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
Battery Charger - 55V 4-Switch Buck-Boost Controller with I2C interface
EN_SYNC_OUT: DISABLED SYNC_IN_FALLING: DISABLED VDET_EN: ENABLED PCM_EN: ENABLED (30%)
10V - 36 V
LM51772 Evaluation module p.13
Power Designer for LM51772

Schematic: User - LED Indicators.kicad_sch

Parts:
LED1101: YELLOW; LED_1206_3216Metric; Manufacturer Part Number 599-0240-007F
Q1101: PMV90ENER; SOT-23-3; Manufacturer Part Number PMV90ENER
R1101: 56R 1% 0.5W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; Manufacturer Part Number SG73P2ATTD56R0F
R1102: 100R 1% 0.2W; R_0402_1005Metric; Manufacturer Part Number CRCW0402100RFKEDHP
R1103: 100k 1%; R_0402_1005Metric; Manufacturer Part Number ERJ-PA2F1003X

Connections:
+3V3: R1101.1; also elsewhere on the board
/Project Architecture/MCU - Unit/LED_DBG: R1102.2, R1103.1; also elsewhere on the board
GND: Q1101.2 (S), R1103.2; also elsewhere on the board
unnamed: LED1101.2 (A), R1101.2
unnamed: LED1101.1 (K), Q1101.3 (D)
unnamed: Q1101.1 (G), R1102.1

Notes on the sheet:
DESIGN NOTE - 3V3 STATUS LED 599-0240-007F has a typical luminous intensity of 126mcd (millicandela) @ 20 mA. Typ. Vf = 2.1V Max Vf = 2.5V Typ. If = (3.3V - 2.1V)/56hm = 21 mA Max. If = (3.3V - 2.5)/56hm = 14 mA P = 2.1V×21mA = 44 mW < 72 mW (max rating)
[${#}] ${TITLE}
LED Indicators
Inspired by Amulet controller Schematics by Vincent Nguyen

Schematic: Sensor - Battery.kicad_sch, Sensing - Battery

Parts:
C901: 100n X7R 50V; C_0402_1005Metric; Manufacturer Part Number UMK105B7104KVHF
NT901, NT902: NetTie_CSA; NetTie-2_SMD_Pad0.5mm
U901: INA239AQDGSRQ1; Manufacturer Part Number INA239AQDGSRQ1

Connections:
+3V3: C901.1, U901.6 (VS); also elsewhere on the board
+VBAT: NT901.1, NT902.1; also elsewhere on the board
/Project Architecture/MCU - Unit/SPI_CLK: U901.5 (SCLK); also elsewhere on the board
/Project Architecture/MCU - Unit/SPI_MISO: U901.4 (MISO); also elsewhere on the board
/Project Architecture/MCU - Unit/SPI_MOSI: U901.2 (MOSI); also elsewhere on the board
/Project Architecture/MCU - Unit/SPI_NCS: U901.1 (CS); also elsewhere on the board
/Project Architecture/Sensing - Battery/ALERT: U901.3 (ALERT)
/Project Architecture/Sensing - Battery/shunt_bat+: NT901.2, U901.8 (VBUS), U901.10 (IN+)
/Project Architecture/Sensing - Battery/shunt_bat-: NT902.2, U901.9 (IN-)
GND: C901.2, U901.7 (GND); also elsewhere on the board

Notes on the sheet:
[${#}] ${TITLE}
Discharge Voltage & Discharge Current Sensor + Temperature Sensor
Inspired by Geode PDB Schematics by Federico Bise

Schematic: Interface - Connectors.kicad_sch

Parts:
C1001, C1002, C1003: 100n X7R 50V; C_0402_1005Metric; Manufacturer Part Number UMK105B7104KVHF
D1001: D5V0P4UR6SO-7; D5V0P4UR6SO-7 SOT95P285X140-6N; Manufacturer Part Number D5V0P4UR6SO-7
D1002: PRTR5V0U2X; SOT-143; Manufacturer Part Number PRTR5V0U2X,215
J1001: FTSH-107-01-F-DV-K; FTSH-107-XX-YYY-DV-K; Manufacturer Part Number FTSH-107-01-F-DV-K
J1002: USB4105-GF-A; GCT_USB4105-GF-A; Manufacturer Part Number USB4105-GF-A
J1003: PPTC042LFBN-RC; PinSocket_2x04_P2.54mm_Vertical; Manufacturer Part Number PPTC042LFBN-RC
R1001, R1002, R1003, R1004: 10k 1%; R_0402_1005Metric; Manufacturer Part Number SG73P1EWTTP1002F
R1005, R1006, R1007, R1008, R1011, R1012: 27R 1%; R_0402_1005Metric; Manufacturer Part Number RCS040227R0FKED
R1009, R1010: 5k1 1%; R_0402_1005Metric; Manufacturer Part Number RCS04025K10FKED
TP1001: VIN2; TestPoint_Pad_D1.0mm
TP1002: GND; TestPoint_Pad_D1.0mm

Connections:
+3V3: C1001.1, D1001.5 (VCC), J1001.1, J1001.14, J1003.2, J1003.7, R1001.1, R1002.1, R1003.1, R1004.1; also elsewhere on the board
+VBUS: C1002.1, C1003.1, D1002.4 (VCC), J1002.A4 (VBUS), J1002.A9 (VBUS), J1002.B4 (VBUS), J1002.B9 (VBUS), TP1001.1; also elsewhere on the board
/Project Architecture/Interface - Connectors/CC1: J1002.A5 (CC1), R1009.2
/Project Architecture/Interface - Connectors/CC2: J1002.B5 (CC2), R1010.2
/Project Architecture/Interface - Connectors/GPIO35: J1003.3; also elsewhere on the board
/Project Architecture/Interface - Connectors/GPIO36: J1003.4; also elsewhere on the board
/Project Architecture/Interface - Connectors/GPIO37: J1003.5; also elsewhere on the board
/Project Architecture/Interface - Connectors/GPIO38: J1003.6; also elsewhere on the board
/Project Architecture/Interface - Connectors/MTCK: D1001.3 (I/O2), J1001.6, R1003.2, R1006.1, R1006.2; also elsewhere on the board
/Project Architecture/Interface - Connectors/MTDI: D1001.6 (I/O4), J1001.10, R1001.2, R1008.1, R1008.2; also elsewhere on the board
/Project Architecture/Interface - Connectors/MTDO: D1001.4 (I/O3), J1001.8, R1002.2, R1007.1, R1007.2; also elsewhere on the board
/Project Architecture/Interface - Connectors/MTMS: D1001.1 (I/O1), J1001.4, R1004.2, R1005.1, R1005.2; also elsewhere on the board
/Project Architecture/Interface - Connectors/SBU1: J1002.A8 (SBU1)
/Project Architecture/Interface - Connectors/SBU2: J1002.B8 (SBU2)
/Project Architecture/Interface - Connectors/USB_C+: D1002.3 (I/O2), J1002.A6 (D+), J1002.B6 (D+), R1012.2
/Project Architecture/Interface - Connectors/USB_C-: D1002.2 (I/O1), J1002.A7 (D-), J1002.B7 (D-), R1011.2
/Project Architecture/Interface - Connectors/USB_D+: R1012.1; also elsewhere on the board
/Project Architecture/Interface - Connectors/USB_D-: R1011.1; also elsewhere on the board
GND: C1001.2, C1002.2, C1003.2, D1001.2 (VSS), D1002.1 (GND), J1001.2, J1001.3, J1001.5, J1001.7, J1001.9, J1001.11, J1001.12, J1001.13, J1002.A1 (GND), J1002.A12 (GND), J1002.B1 (GND), J1002.B12 (GND), J1002.S1 (SHIELD), J1003.1, J1003.8, R1009.1, R1010.1, TP1002.1; also elsewhere on the board

Notes on the sheet:
Test Points
GND
DESIGN NOTE: 10kΩ pull-up resistors on the JTAG lines of the ESP32-S3 can improve reliability and reduce noise issues
Additional I/Os
Series Resistors are typically added on the D+ and D- lines to help with impedance matching, which reduces signal reflections and ensures reliable data transmission. They also dampen the signal edges, minimizing EMI and improving overall signal integrity, especially in USB 2.0 designs. The 27Ω valu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
USB-C port
DESIGN NOTE: The 22Ω resistors in series with each JTAG signal line help reduce ringing and noise by damping high-frequency signals. This is a good practice and is generally recommended in signal integrity guidelines for JTAG and other high-speed signals.
JTAG (Debug) Port
Power Rails
D5V0P4UR6SO-7: Reverse working =3.3V Reverse breakdown =4.5V Reverse clamping =6V
[${#}] ${TITLE}
DESIGN NOTE - USB-C Configuration Channel pins: Device Detection: When the CC1 and CC2 pins have pull-down resistors, the USB-C power source detects that a "sink" device is connected and needs power. This signals to the power source to supply the default 5V over the VBUS line. Power Negotiation: Th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
DESIGN NOTE: The 0.1µF cap. is a standard bypass capacitor that filters high-frequency noise.

Schematic: MCU - Unit.kicad_sch

Parts:
C401, C404, C411: 1u X7R 50V; C_0603_1608Metric; Manufacturer Part Number CC0603KRX7R9BB105
C402, C405, C406, C407, C408, C413: 100n X7R 50V; C_0402_1005Metric; Manufacturer Part Number UMK105B7104KVHF
C403: 10u X7R 50V; C_1206_3216Metric; Manufacturer Part Number CL31B106KBHNNNE
C409, C410: 10p X7R 25V; C_0402_1005Metric; Manufacturer Part Number 04025U100BAT2A
C412: 10n X7R 50V; C_0402_1005Metric; Manufacturer Part Number 04025C103JAT2A
L401: 2n (0.1n); L_0402_1005Metric; Manufacturer Part Number LQG15WH2N0B02D
R401, R402, R403, R404, R405, R406, R407, R408: 10k 1%; R_0402_1005Metric; Manufacturer Part Number SG73P1EWTTP1002F
S401, S402: B3U-1100P-B; B3U1100PB; Manufacturer Part Number B3U-1100P-B
TP401: MTCK; TestPoint_Pad_D1.0mm
TP402: MTDO; TestPoint_Pad_D1.0mm
TP403: MTDI; TestPoint_Pad_D1.0mm
TP404: MTMS; TestPoint_Pad_D1.0mm
TP405: SPI_NCS; TestPoint_Pad_D1.0mm
TP406: SPI_MOSI; TestPoint_Pad_D1.0mm
TP407: SPI_MISO; TestPoint_Pad_D1.0mm
TP408: SPI_CLK; TestPoint_Pad_D1.0mm
TP409: SCL; TestPoint_Pad_D1.0mm
TP410: SDA; TestPoint_Pad_D1.0mm
TP411: CHARGER_STATUS; TestPoint_Pad_D1.0mm
TP412: LED_DBG; TestPoint_Pad_D1.0mm
TP413: PRIORITY; TestPoint_Pad_D1.0mm
TP414: VALID1; TestPoint_Pad_D1.0mm
TP415: VALID2; TestPoint_Pad_D1.0mm
TP416: PGOOD; TestPoint_Pad_D1.0mm
TP417: FAULT1; TestPoint_Pad_D1.0mm
TP418: FAULT2; TestPoint_Pad_D1.0mm
TP419: IMON1; TestPoint_Pad_D1.0mm
TP420: IMON2; TestPoint_Pad_D1.0mm
TP421, TP422: GND; TestPoint_Pad_D1.0mm
U401: ESP32-S3FN8; QFN-56-1EP_7x7mm_P0.4mm_EP4x4mm; Manufacturer Part Number ESP32-S3FN8
Y401: ECS-400-10-33B-CKM-TR; XTAL_ECS-400-10-33B-CKM-TR; Manufacturer Part Number ECS-400-10-33B-CKM-TR

Connections:
+3V3: C401.1, C402.1, C403.1, C404.1, C405.1, C406.1, C407.1, C408.1, C411.1, C412.1, L401.1, L401.2, R401.1, R402.1, R403.1, R404.1, R405.1, R406.1, R407.1, R408.1, U401.2 (VDD3P3), U401.3 (VDD3P3), U401.20 (VDD3P3_RTC), U401.29 (VDD_SPI), U401.46 (VDD3P3_CPU), U401.55 (VDDA), U401.56 (VDDA); also elsewhere on the board
/Project Architecture/Interface - Connectors/GPIO35: U401.40 (GPIO35); also elsewhere on the board
/Project Architecture/Interface - Connectors/GPIO36: U401.41 (GPIO36); also elsewhere on the board
/Project Architecture/Interface - Connectors/GPIO37: U401.42 (GPIO37); also elsewhere on the board
/Project Architecture/Interface - Connectors/GPIO38: U401.43 (GPIO38); also elsewhere on the board
/Project Architecture/Interface - Connectors/MTCK: TP401.1, U401.44 (MTCK); also elsewhere on the board
/Project Architecture/Interface - Connectors/MTDI: TP403.1, U401.47 (MTDI); also elsewhere on the board
/Project Architecture/Interface - Connectors/MTDO: TP402.1, U401.45 (MTDO); also elsewhere on the board
/Project Architecture/Interface - Connectors/MTMS: TP404.1, U401.48 (MTMS); also elsewhere on the board
/Project Architecture/Interface - Connectors/USB_D+: U401.26 (GPIO20/USB_D+); also elsewhere on the board
/Project Architecture/Interface - Connectors/USB_D-: U401.25 (GPIO19/USB_D-); also elsewhere on the board
/Project Architecture/MCU - Unit/CHARGER_STATUS: R406.2, TP411.1, U401.19 (GPIO14); also elsewhere on the board
/Project Architecture/MCU - Unit/CHUP_PU: R407.2, S401.1, U401.4 (CHIP_PU)
/Project Architecture/MCU - Unit/CLOCK_IN: C409.2, U401.54 (XTAL_P), Y401.1 (IN/OUT)
/Project Architecture/MCU - Unit/CLOCK_OUT: C410.2, U401.53 (XTAL_N), Y401.3 (OUT/IN)
/Project Architecture/MCU - Unit/FAULT1: R404.2, TP417.1, U401.38 (GPIO33); also elsewhere on the board
/Project Architecture/MCU - Unit/FAULT2: R405.2, TP418.1, U401.39 (GPIO34); also elsewhere on the board
/Project Architecture/MCU - Unit/GPIO0: R408.2, S402.1, U401.5 (GPIO0)
/Project Architecture/MCU - Unit/GPIO3: U401.8 (GPIO3)
/Project Architecture/MCU - Unit/GPIO17: U401.23 (GPIO17)
/Project Architecture/MCU - Unit/GPIO18: U401.24 (GPIO18)
/Project Architecture/MCU - Unit/GPIO45: U401.51 (GPIO45)
/Project Architecture/MCU - Unit/GPIO46: U401.52 (GPIO46)
/Project Architecture/MCU - Unit/IMON1: TP419.1, U401.6 (GPIO1); also elsewhere on the board
/Project Architecture/MCU - Unit/IMON2: TP420.1, U401.7 (GPIO2); also elsewhere on the board
/Project Architecture/MCU - Unit/LED_DBG: TP412.1, U401.27 (GPIO21); also elsewhere on the board
/Project Architecture/MCU - Unit/LNA_IN: U401.1 (LNA_IN)
/Project Architecture/MCU - Unit/PGOOD: TP416.1, U401.18 (GPIO13); also elsewhere on the board
/Project Architecture/MCU - Unit/PRIORITY: TP413.1, U401.15 (GPIO10); also elsewhere on the board
/Project Architecture/MCU - Unit/SCL: R401.2, TP409.1, U401.9 (GPIO4); also elsewhere on the board
/Project Architecture/MCU - Unit/SDA: R402.2, TP410.1, U401.10 (GPIO5); also elsewhere on the board
/Project Architecture/MCU - Unit/SPICLK: U401.33 (SPICLK)
/Project Architecture/MCU - Unit/SPICLK_N: U401.36 (SPICLK_N)
/Project Architecture/MCU - Unit/SPICLK_P: U401.37 (SPICLK_P)
/Project Architecture/MCU - Unit/SPICS0: U401.32 (SPICS0)
/Project Architecture/MCU - Unit/SPICS1: U401.28 (SPICS1)
/Project Architecture/MCU - Unit/SPID: U401.35 (SPID)
/Project Architecture/MCU - Unit/SPIHD: U401.30 (SPIHD)
/Project Architecture/MCU - Unit/SPIQ: U401.34 (SPIQ)
/Project Architecture/MCU - Unit/SPIWP: U401.31 (SPIWP)
/Project Architecture/MCU - Unit/SPI_CLK: TP408.1, U401.14 (GPIO9); also elsewhere on the board
/Project Architecture/MCU - Unit/SPI_MISO: TP407.1, U401.13 (GPIO8); also elsewhere on the board
/Project Architecture/MCU - Unit/SPI_MOSI: TP406.1, U401.12 (GPIO7); also elsewhere on the board
/Project Architecture/MCU - Unit/SPI_NCS: R403.2, TP405.1, U401.11 (GPIO6); also elsewhere on the board
/Project Architecture/MCU - Unit/U0RXD: U401.50 (U0RXD)
/Project Architecture/MCU - Unit/U0TXD: U401.49 (U0TXD)
/Project Architecture/MCU - Unit/VALID1: TP414.1, U401.16 (GPIO11); also elsewhere on the board
/Project Architecture/MCU - Unit/VALID2: TP415.1, U401.17 (GPIO12); also elsewhere on the board
/Project Architecture/MCU - Unit/XTAL_32K_N: U401.22 (XTAL_32K_N)
/Project Architecture/MCU - Unit/XTAL_32K_P: U401.21 (XTAL_32K_P)
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.1, C410.1, C411.2, C412.2, C413.2, S401.SH, S402.2, S402.SH, TP421.1, TP422.1, U401.57 (GND), Y401.2 (GND), Y401.4 (GND); also elsewhere on the board
unnamed: C413.1, S401.2

Notes on the sheet:
MCU Additional I/Os
MCU Chip Reset
SPI Bus to Discharge Sensor
GND
Charger Status
JTAG (Debug) port
DESIGN NOTE - I2C pull-Up resistors: Rmin = (VDDmax - VOLmax) / IOL System I/O voltage: VDD = 3.3V +- 5% -> 3.47V Low level output volatge (I2C specs): VOLmax = 0.4V Low level output current (I2C specs): IOL = 3mA Rmin = (3.47V - 0.4V) / 3mA ≈ 1k Ohm Rmax ≈ (1.18 x trmax ) / Cb Standard mode (I2C s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
User LED
[${#}] ${TITLE}
DESIGN NOTE - CLK caps: Cl = 10pF Cp = 5pF C1 = C2 Cl = (c1 x c2)/(c1+c2) + Cp 10pF = C1/2 + Cp C1 = C2 = 10pF
Test Points
The pullup on the CS pin ensure that the slave remain deselected when the master is in reset or starting up. In that case, its pins are usually hi-Z and thus floating, which could lead to multiple slaves being selected and driving the MISO bus (resulting in short-circuits). CS is an active low line.
SPI - Sense
MCU JTAG Boot
JTAG - Debug
I2C - Charge
LAYOUT NOTE: Place each capacitor close to the relevant pin to minimize loop inductance.
MCU I/O
I2C Bus to Battery Charger
USB-C Interface
MCU POWER
3V3 Buck Status
OTHER SIGNALS
Drivers Status & Sensing
DESIGN NOTE: USB flashing is fully automated because of its ability to reset the ESP32 directly, while JTAG debugging operates through distinct dedicated pins that do not handle the board's power state changes automatically. Therefore, the BOOT button is necessary to enable flash mode when using JT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
DESIGN NOTE: Debouncing: It smooths out any quick, unintended changes in voltage due to mechanical bounce in the button switch. This ensures that when you press the reset button, it reliably resets without multiple unintended toggles. Power Stabilization: It can also help stabilize the power when t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
Espressif Datasheet p.25 (CHIP_PU)
Phil's Lab - SPI Hardware & PCB Design
Espressif Datasheet p.30 (GPIO0 boot)
Espressif Scematic Checklist

Board: 4 copper layers, 95.0 x 70.0 mm, 233 parts (0 on the bottom side), 106 nets.

Other parts of the board:
kibuzzard-67161F44: G***; kibuzzard-67161F44
kibuzzard-67141537: G***; kibuzzard-67141537

File Power/ElonMux/Manufacturing/Assembly/ElonMux_bom_1.0.csv (part):

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet,Manufacturer Part Number,Supplier,Manufacturer,Supplier Part Number
1,Unpolarized capacitor,C,C402 C405 C406 C407 C408 C413 C606 C613 C711 C712 C713 C714 C716 C717 C718 C722 C801 C802 C803 C804 C805 C806 C807 C901 C902 C1001 C1002 C1003,100n X7R 50V,C_0402_1005Metric,28,https://www.mouser.ch/datasheet/2/396/taiyo_yuden_12132018_m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,UMK105B7104KVHF,Mouser Electronics,TAIYO YUDEN,963-UMK105B7104KVHF
2,Unpolarized capacitor,C,C412 C715,10n X7R 50V,C_0402_1005Metric,2,https://www.mouser.ch/datasheet/2/40/KGM_X7R-3223212.pdf,04025C103JAT2A,Mouser Electronics,KYOCERA AVX,581-04025C103JAT2A
3,Unpolarized capacitor,C,C409 C410,10p X7R 25V,C_0402_1005Metric,2,https://www.mouser.ch/datasheet/2/40/U_Series-2942365.pdf,04025U100BAT2A,Mouser Electronics,KYOCERA AVX,581-04025U100BAT2A
4,Unpolarized capacitor,C,C607,10p X7R 25V,C_0603_1608Metric,1,https://www.mouser.ch/datasheet/2/40/X7RDielectric-2943470.pdf,06033C100KAT2A,Mouser Electronics,KYOCERA AVX,581-06033C100KAT2A
5,Unpolarized capacitor,C,C403 C604 C611 C704 C705 C706 C707 C708 C709,10u X7R 50V,C_1206_3216Metric,9,https://www.mouser.ch/datasheet/2/585/MLCC-1837944.pdf,CL31B106KBHNNNE,Mouser Electronics,Samsung Electro-Mechanics,187-CL31B106KBHNNNE
6,Multilayer Ceramic Capacitors MLCC - SMD/SMT 1000V 1kpF 0603 X7R 20%,C_Small,C1203,1n X7R 1kV,C_0603_1608Metric,1,https://www.mouser.fr/datasheet/2/447/KEM_C1010_X7R_HV_SMD-3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,C0603C102MDRAC7081,Mouser Electronics,KEMET,80-C0603C102MDRAC
7,Unpolarized capacitor,C,C401 C404 C411 C601 C602 C605 C612 C808 C809 C810 C811,1u X7R 50V,C_0603_1608Metric,11,https://www.mouser.ch/datasheet/2/447/UPY_GPHC_X7R_6_3V_to_2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,CC0603KRX7R9BB105,Mouser Electronics,YAGEO,603-CC603KRX7R9BB105
8,Unpolarized capacitor,C,C721,220p X7R 50V,C_0402_1005Metric,1,https://www.mouser.ch/datasheet/2/40/KGM_X7R-3223212.pdf,04025C221JAT2A,Mouser Electronics,KYOCERA AVX,581-04025C221JAT2A
9,Unpolarized capacitor,C,C608 C609 C719 C720,22u X5R 50V,C_0603_1608Metric,4,https://www.mouser.ch/datasheet/2/281/1/GRT188R61A226ME13_01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,GRT188R61A226ME13D,Mouser Electronics,Murata Electronics,81-GRT188R61A226ME13
10,"Polarized capacitor, US symbol",C_Polarized_US,C701 C702 C703 C710,33u 80V,Hybrid_F_VP,4,https://www.mouser.ch/datasheet/2/315/ABA0000C1234-1218024.pdf,EEH-ZC1K330V,Mouser Electronics,Panasonic,667-EEH-ZC1K330V
11,Unpolarized capacitor,C,C603 C610 C614,4u7 X7R 50V,C_0805_2012Metric,3,https://product.tdk.com/system/files/dam/doc/product/capacit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,CGA4J1X7R1H475K125AC,Mouser Electronics,TDK,810-CGA4J1X7R1H475K1
12,ESD Suppressors / TVS Diodes General Protection PP,D5V0P4UR6SO-7,D1001,D5V0P4UR6SO-7,D5V0P4UR6SO-7 SOT95P285X140-6N,1,https://www.diodes.com//assets/Datasheets/D5V0P4UR6SO.pdf,D5V0P4UR6SO-7,Mouser Electronics,Diodes Incorporated,621-D5V0P4UR6SO-7
13,"PMEG4030EXE-Q - 40 V, 3 A Schottky barrier rectifier@en-us",PMEG4030EXEX_1,D802 D803,"PMEG4030ER,115",Nexperia_CFP3_SOD-123W,2,https://www.mouser.ch/datasheet/2/916/PMEG4030ER-2938673.pdf,"PMEG4030ER,115",Mouser Electronics,Nexperia,771-PMEG4030ER115
14,"Ultra low capacitance double rail-to-rail ESD protection diode, SOT-143",PRTR5V0U2X,D1002,PRTR5V0U2X,SOT-143,1,https://assets.nexperia.com/documents/data-sheet/PRTR5V0U2X.pdf,"PRTR5V0U2X,215",Mouser Electronics,Nexperia,771-PRTR5V0U2X-T/R
15,"Littelfuse SMBJ33CA, Bi-Directional TVS Diode, 600W, 2-Pin DO-214AA",SMBJ30CA,D501 D502 D503 D504,SMBJ33CA,DIOM5436X244N,4,https://www.littelfuse.com/media?resourcetype=datasheets&ite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,SMBJ33CA,Mouser Electronics,LITTELFUSE,576-SMBJ33CA
16,"VISHAY - VBT3045C-E3/8W - SCHOTTKY RECTIFIER ARRAY, 30A, TO-263AB",VBT3045C-E3_8W,D801,STPS15L60CB-TR,STPS15L60CB-TR,1,https://www.vishay.com/docs/89360/vbt3045c.pdf,STPS15L60CB-TR,Mouser Electronics,STMicroelectronics,511-STPS15L60CB-TR
17,1 kOhms @ 100 MHz 1 Signal Line Ferrite Bead 0805 (2012 Metric) 1A 300mOhm,FerriteBead,FB601 FB602,1k @ 100MHz,R_0805_2012Metric,2,https://www.we-online.com/katalog/datasheet/742792096.pdf,742792096,Mouser Electronics,Würth Elektronik,710-742792096
18,"Switching Voltage Regulators 42V, 2.5A Synchronous Step-Down Regulator with Lossless PowerPath",LTC3126EFE#TRPBF,IC601,LTC3126IUFD#PBF,LTC3126EUFD,1,https://www.mouser.fr/datasheet/2/609/3126f-2954520.pdf,LTC3126IUFD#PBF,Mouser Electronics,Analog Devices,584-LTC3126IUFD#PBF
19,Gate Drivers Fast 150V Protected High Side NMOS Static Switch Driver,LTC7000EMSE#PBF_1,IC801 IC802,LTC7000EMSE#PBF,LTC7000EMSE#PBF,2,https://www.analog.com/media/en/technical-documentation/data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,LTC7000EMSE#PBF,Mouser Electronics,Analog Devices,584-LTC7000EMSEPBF
20,TPS3701 36V Window Supervisor with Internal Ref for Overvoltage and Undervoltage Detection,TPS3701DDCR,IC803,TPS3701DDCR,TPS3701DDCR,1,http://www.ti.com/lit/gpn/tps3701,TPS3701DDCR,Mouser Electronics,Texas Instruments,595-TPS3701DDCR
21,"High Reliability HDR Strips 0.050""",FTSH-107-01-F-DV-K,J1001,FTSH-107-01-F-DV-K,FTSH-107-XX-YYY-DV-K,1,http://suddendocs.samtec.com/prints/ftsh-1xx-xx-xxx-dv-xxx-x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,FTSH-107-01-F-DV-K,Mouser Electronics,SAMTEC,200-FTSH10701FDVK
22,"Generic connector, double row, 02x04, odd/even pin numbering scheme (row 1 odd numbers, row 2 even numbers), script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_02x04_Odd_Even,J1003,PPTC042LFBN-RC,PinSocket_2x04_P2.54mm_Vertical,1,https://mm.digikey.com/Volume0/opasdata/d220001/medias/docus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,PPTC042LFBN-RC,Digikey,Sullins Connector Solutions,S7072-ND
23,USB 2.0-only 16P Type-C Receptacle connector,USB_C_Receptacle_USB2.0_16P,J1002,USB4105-GF-A,GCT_USB4105-GF-A,1,https://www.usb.org/sites/default/files/documents/usb_type-c.zip,USB4105-GF-A,Mouser Electronics,GCT,640-USB4105-GF-A
24,Socket; DC supply; XT60; female; PIN: 2; on PCBs; THT; yellow; 30A; 500V,Conn_01x02_Mounting_1,J502 J504,XT60PW-F,AMASS_XT60PW-F_1x02_P7.20mm_Horizontal,2,https://www.tme.com/Document/1191bc2fa3aee3c446e5a895fd8f798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,XT60PW-F,Transfer Multisort Elektronik,AMASS,XT60PW-F
25,Socket; DC supply; XT60; male; PIN: 2; on PCBs; THT; yellow; 30A; 500V,Conn_01x02_Mounting_1,J501 J503,XT60PW-M,AMASS_XT60PW-M_1x02_P7.20mm_Horizontal,2,https://www.tme.eu/Document/b13629717d44ae038681dba08d18c0b6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,XT60PW-M,Transfer Multisort Elektronik,AMASS,XT60PW-M
26,Power Inductors - SMD WE-XHMI 1.0 uH  10.00 A  13.44 mOhms 4020,74439323010,L701,1u,74439323010,1,https://www.we-online.com/components/products/datasheet/7443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,74439323010,Mouser Electronics,Wurth Elektronik,710-74439323010
27,Fixed Inductors 4.7uH 5%,IMC0805ER4R7J01,L601,4u7,L_0805_2012Metric,1,https://www.vishay.com/docs/34115/imc08051.pdf,IMC0805ER4R7J01,Mouser Electronics,Vishay,70-IMC0805ER4R7J01
28,RF Inductors - SMD IND 0402 24nH S-HQ AEC Q200 RF IND,LQP02HQ2N0B02E,L402,24n 2%,L_0402_1005Metric,1,https://product.tdk.com/system/files/dam/doc/product/inducto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,MHQ1005P24NGTD25,Mouser Electronics,TDK,810-MHQ1005P24NGTD25
29,RF Inductors - SMD,LQP02HQ2N0B02E,L401,2n (0.1n),L_0402_1005Metric,1,https://www.mouser.ch/datasheet/2/281/1/JELF243B_9118-2079820.pdf,LQG15WH2N0B02D,Mouser Electronics,Murata Electronics,81-LQG15WH2N0B02D
30,Red 640nm LED Indication - Discrete 1.85V 1206 (3216 Metric),SM1206SRC,LED601 LED701 LED801 LED802,RED,LED_1206_3216Metric,4,https://www.bivar.com/parts_content/Datasheets/SM1206SRC.pdf,SM1206SRC,Mouser Electronics,Bivar,749-SM1206SRC
31,DEL standard - CMS SMD 1206 YELLOW,SM1206GC,LED1101,YELLOW,LED_1206_3216Metric,1,https://s3-us-west-2.amazonaws.com/catsy.557/Dialight_CBI_da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,599-0240-007F,Mouser Electronics,Dialight,645-599-0240-007F
32,"100A Id, 60V Vds, NexFET N-Channel Power MOSFET, 2.2mOhm Ron, 41nC Qg(typ), SON8 5x6mm",CSD18540Q5B,Q701 Q702 Q703 Q704 Q801 Q802 Q803 Q804,CSD18540Q5B,TDSON-8-1,8,http://www.ti.com/lit/gpn/csd18540q5b,CSD18540Q5B,Mouser Electronics,Texas Instruments,595-CSD18540Q5B
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
## KiCad design hats/power_hat/power_hat.kicad_pcb

Parts:
H1, H2, H3, H4: M2; MountingHole_2.2mm_M2_Pad_Via
J1, J2, J3, J4, J6, J8: XT30PW-M/Terminal block; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J5, J7: Conn_01x02_Pin; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal

Connections:
GND: H1.1, H2.1, H3.1, H4.1, J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2
VCC: J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1

Board: 2 copper layers, 12 parts (0 on the bottom side), 2 nets, no tracks yet.
