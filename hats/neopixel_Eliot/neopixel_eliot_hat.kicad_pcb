# Repository EPFLXplore/ERC_AV_HW

File README.md:

# Electronics Subsystem Harware Repository

## How to clone

`git clone https://github.com/EPFLXplore/AV_HW_workspace.git`

`git submodule update --init --remote`

## KiCad design hats/neopixel_Eliot/neopixel_eliot_hat.kicad_pcb

Board: 4 copper layers, 30.7 x 30.7 mm, 55 parts (13 on the bottom side), 35 nets.

Parts:
C1, C4, C6, C7: 4.7uF; C_0402_1005Metric
C2, C3, C16, C17, C18, C20: 100n; C_0402_1005_DensityHigh
C5, C11, C12: 0.1uF; C_0603_1608Metric
C9, C10: 100n X7R 50V; C_0402_1005_DensityHigh
C13: 4.7uF; C_0603_1608Metric
C14: 22uF; CP_EIA-3216-18_Kemet-A
C15: 10uF; C_0805_2012Metric
D1: PRTR5V0U2X; SOT-143
D2: RED; LED_0603_1608Metric
D3: SMF5.0CA-TP; D_SOD-123
D4, D5: PESD4USB3U-TBSX; SOT1176D
G1: Xplore_Logo; Xplore_Logo_X_only_20mm
IC1: TPS2116DRLR; SOTFL50P160X60-8N
IC2: TPS259621DDAR; SOIC127P600X170-9N
IC4: STM32F411CEU6TR; QFN50P700X700X60-49N-D
J1: B3B-XH-A(LF)(SN); JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J2: Hat_connector
J4: SWD_02x05_1.27mm; FTSH-105-01-F-D-RA-K
J5: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
LV1: SN74LVC1T45DCKT; SOP65P210X110-6N
Q3: PJA3405; SOT-23
R1, R2: 10k; R_0603_1608Metric
R3: 100R; R_0603_1608Metric
R4, R5: 5.1k; R_0201_0603Metric
R6, R8: 27R 1% 1/5W; R_0402_1005_DensityHigh
R7: 464k; C_0402_1005Metric
R9, R10: 1k8; R_0402_1005Metric
R11: 10k; R_0402_1005Metric
R12: 50R; R_0603_1608Metric
R13: 33.2k; R_0402_1005Metric
R14: 47.5k; R_0603_1608Metric
R15: 1.8k; R_0402_1005Metric
S1, S2: EVP-BB2A9B000; EVPBB2A9B000
TP1: LED_Sig; TestPoint
TP2: VBUS_REV; TestPoint
TP5: nFAULT; TestPoint
U2: AMS1117; SOT-223-3_TabPin2
Y1: CSTNE24M0VH3C000R0

Connections:
+3V3: C1.1, C2.1, C5.1, C7.1, C10.1, C16.1, C17.1, C18.1, C20.1, IC2.5 (OUT), IC4.9 (VDDA/VREF+), IC4.24 (VDD_1), IC4.36 (VDD_2), IC4.48 (VDD_3), J4.1 (VTref), LV1.1 (VCCA), R2.1, R9.1, R10.1, R11.1, S2.1 (A), S2.2 (A')
+5V_MCU: C12.1, C13.1, IC1.3 (VIN1), IC1.4 (PR1), IC1.5 (MODE), J2.15 (5V), J2.16 (5V)
+5V_MUX: C3.1, C4.1, C15.1, IC1.2 (VOUT_1), IC1.7 (VOUT_2), J1.3, LV1.6 (VCCB), U2.3 (VI)
/D+: D1.3 (I/O2), J5.A6 (D+), J5.B6 (D+), R6.1
/D-: D1.2 (I/O1), J5.A7 (D-), J5.B7 (D-), R8.1
/DATA_5V: J1.2, R3.1
/DIR_LED: LV1.5 (DIR), R2.2
/I2C1_SCL: IC4.42 (PB6), J2.7 (I2C_SCL), R9.2
/I2C1_SDA: IC4.43 (PB7), J2.8 (I2C_SDA), R10.2
/NRST: C9.1, D4.1 (K), D4.10 (K), IC4.7 (NRST), J4.10 (nRESET), S1.3 (B'), S1.4 (B)
/SIGNAL_LED: IC4.38 (PA15), LV1.3 (A), TP1.1
/SPI_CS: D5.1 (K), D5.10 (K), IC4.14 (PA4), J2.6 (SPI_CS)
/SPI_MISO: D5.2 (K), D5.9 (K), IC4.16 (PA6), J2.5 (SPI_MISO)
/SPI_MOSI: D5.4 (K), D5.7 (K), IC4.17 (PA7), J2.4 (SPI_MOSI)
/SPI_SCK: D5.5 (K), D5.6 (K), IC4.15 (PA5), J2.3 (SPI_SCK)
/SWCLK: D4.4 (K), D4.7 (K), IC4.37 (PA14), J4.4 (SWCLK/TCK)
/SWDIO: D4.5 (K), D4.6 (K), IC4.34 (PA13), J4.2 (SWDIO/TMS)
/USB+: IC4.33 (PA12), R6.2
/USB-: IC4.32 (PA11), R8.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, D1.1 (GND), D2.1 (K), D3.1 (A1), D4.3 (A), D4.8 (A), D5.3 (A), D5.8 (A), IC1.1 (GND), IC2.1 (GND_1), IC2.9 (GND_2), IC4.8 (VSSA/VREF-), IC4.23 (VSS_1), IC4.35 (VSS_2), IC4.47 (VSS_3), IC4.49 (EP), J1.1, J2.1 (GND), J4.3 (GND), J4.5 (GND), J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J5.S1 (SHIELD), LV1.2 (GND), Q3.1 (G), R1.2, R4.2, R5.2, R14.1, R15.1, S1.1 (A), S1.2 (A'), U2.1 (ADJ), Y1.2 (GND)
unnamed: D2.2 (A), R12.1
unnamed: IC2.3 (EN/UVLO), R7.1, R13.2
unnamed: IC2.7 (ILM), R15.2
unnamed: C11.1, C14.1, IC2.4 (IN), R7.2, R12.2, U2.2 (VO)
unnamed: IC2.8 (OVLO/OVCSEL), R13.1, R14.2
unnamed: IC2.6 (~FLT), R11.2, TP5.1
unnamed: IC4.44 (BOOT0), R1.1, S2.3 (B'), S2.4 (B)
unnamed: IC4.5 (PH0-OSC_IN), Y1.1 (INPUT)
unnamed: IC4.6 (PH0-OSC_OUT), Y1.3 (OUTPUT)
unnamed: C6.1, IC4.22 (VCAP_1)
unnamed: J5.A5 (CC1), R4.1
unnamed: J5.B5 (CC2), R5.1
unnamed: LV1.4 (B), R3.2
VBUS: D3.2 (A2), J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), Q3.3 (D)
VBUS_REV: D1.4 (VCC), IC1.6 (VIN2), Q3.2 (S), TP2.1

## KiCad design hats/new_imu/Xplore ERC IMU.kicad_pcb

Parts:
C1, C2, C4, C5, C12: 100nF; C_0402_1005Metric
C3, C7: 1uF; C_0402_1005Metric
C6: 2.2uF; C_0402_1005Metric
C8, C9: 4.7nF; C_0402_1005Metric; Mouser ref 581-0402YD475MAT2A
C10: 10uF; C_0805_2012Metric
C11: 22uF; C_0805_2012Metric
CR1, CR2: PESD2CANFD27V-TR; SOT23_PESD2_NEX
CR3, CR4, CR5, CR6, CR7, CR8: SP3205-01ETG; SDO_SOD882_LTF
D1: RED; LED_0603_1608Metric
G1: Xplore_Logo; Xplore_Logo_X_only_10mm
H1, H2, H3, H4: M2; MountingHole_2.2mm_M2
J1, J2: 5025850670; CON_5025850670
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R3, R4, R7: 60R; R_0603_1608Metric; Mouser ref 71-CRCW060360R4FKEAH
R2: 10k; R_0402_1005Metric
R5, R6: 4k7; R_0402_1005Metric
R8: 60R; R_0402_1005Metric
U1: LIS3MDL; LGA-12_2x2mm_P0.5mm
U2: BMI088
U3: LT3960JMSE-PBF; LT3960
U4: AMS1117-3.3; SOT-223-3_TabPin2
U5: D5V0H1B2LP-7B; D5V0H1B2LP_7B

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, C6.1, C11.1, R5.1, R6.2, R8.2, U1.5 (Vdd), U1.6 (Vdd_IO), U1.9 (SDO/SA1), U1.10 (~CS), U2.3 (VDD), U2.7 (PS), U2.11 (VDDIO), U2.14 (CSB1), U3.8 (VCC), U4.2 (VO)
+5V: C7.1, C10.1, C12.2, J2.1, R2.2, U3.6 (VIN), U4.3 (VI), U5.1
/CANSCL+: CR1.2, J2.4, R1.1, U3.4 (CANSCLH)
/CANSCL-: CR1.1, J2.5, R3.2, U3.5 (CANSCLL)
/CANSDA+: CR2.1, J2.3, R4.1, U3.2 (CANSDAH)
/CANSDA-: CR2.2, J2.2, R7.1, U3.1 (CANSDAL)
/DRDY: CR8.1, J1.6, U1.8 (DRDY)
/INT1: CR4.1, J1.2, U2.16 (INT1)
/INT2: CR3.1, J1.1, U2.1 (INT2)
/INT3: CR6.1, J1.4, U2.12 (INT3)
/INT4: CR5.1, J1.3, U2.13 (INT4)
/MAG_INT: CR7.1, J1.5, U1.7 (INT)
/SCL: R5.2, U1.1 (SCL/SPC), U2.8 (SCL/SCK), U3.9 (SCL)
/SDA: R6.1, U1.11 (SDA/SDI/SDO), U2.9 (SDA/SDI), U3.10 (SDA)
/SLD_PIN: JP1.2 (B), U3.7 (EN/MODE)
/SLD_R2: JP1.1 (A), R2.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, CR1.3, CR2.3, CR3.2, CR4.2, CR5.2, CR6.2, CR7.2, CR8.2, D1.1 (K), J1.7, J1.8, J2.6, J2.7, J2.8, U1.2 (GND), U1.3 (GND), U1.12 (GND), U2.2 (NC), U2.4 (GNDA), U2.6 (GNDIO), U2.10 (SDO2), U2.15 (SDO1), U3.3 (GND), U3.11 (GND), U4.1 (GND), U5.2
unnamed: C8.1, R1.2, R3.1
unnamed: C9.1, R4.2, R7.2
unnamed: D1.2 (A), R8.1
unnamed: C5.1, U1.4 (C1)

Notes on the sheet:
CAN and INT/GPIO Headers
Power regulation
I2C Adresses: Gyro: 1101000b (0x68) Accelerometer: 0011000b (0x18)
LIS3MDL Magnetometer
Mounting
float = slave short = master
LT3960 I2C - CAN
BMI088 Accelerometer and Gyroscope
Power flags
Logo

Board: 2 copper layers, 48.3 x 27.8 mm, 42 parts (7 on the bottom side), 21 nets.

File hats/new_imu/BOM.csv:

"Reference","Value","Datasheet","Footprint","Qty","DNP"
"C1,C2,C4,C5,C12","100nF","~","Capacitor_SMD:C_0402_1005Metric","5",""
"C3,C7","1uF","~","Capacitor_SMD:C_0402_1005Metric","2",""
"C6","2.2uF","~","Capacitor_SMD:C_0402_1005Metric","1",""
"C8,C9","4.7nF","https://www.mouser.ch/datasheet/2/40/cx5r_KGM-3223198.pdf","Capacitor_SMD:C_0402_1005Metric","2",""
"C10","10uF","~","Capacitor_SMD:C_0402_1005Metric","1",""
"C11","22uF","~","Capacitor_SMD:C_0402_1005Metric","1",""
"CR1,CR2","PESD2CANFD27V-TR","https://assets.nexperia.com/documents/data-sheet/PESD2CANFD2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","footprints:SOT23_PESD2_NEX","2",""
"D1","RED","https://eu.mouser.com/datasheet/2/588/asset_pdf_5183563-3418814.pdf","LED_SMD:LED_0603_1608Metric","1",""
"D2,D3,D4,D5,D6,D7","PESD5V0S1UL_315","https://assets.nexperia.com/documents/data-sheet/PESD5V0S1UL.pdf","footprints:DIO_PESD5V0S1UL_315","6",""
"J1,J2","5025850670","https://www.molex.com/en-us/products/part-detail/5025850670?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","footprints:CON_5025850670","2",""
"R1,R3,R4,R7,R8","60R","-- mixed values --","Resistor_SMD:R_0402_1005Metric","5",""
"R2","10k","~","Resistor_SMD:R_0402_1005Metric","1",""
"R5,R6","4k7","~","Resistor_SMD:R_0402_1005Metric","2",""
"SW1","CAS-220TA","https://www.nidec-copal-electronics.com/e/catalog/switch/cas.pdf","0_switch_button:7M25000MAAJT","1",""
"U1","LIS3MDL","https://www.st.com/resource/en/datasheet/lis3mdl.pdf","Package_LGA:LGA-12_2x2mm_P0.5mm","1",""
"U2","BMI088","https://www.mouser.ch/datasheet/2/783/BST_BMI088_DS001-1509549.pdf","footprints:BMI088","1",""
"U3","LT3960JMSE-PBF","https://www.mouser.ch/datasheet/2/609/lt3960-1921786.pdf","footprints:LT3960","1",""
"U4","AMS1117-3.3","http://www.advanced-monolithic.com/pdf/ds1117.pdf","Package_TO_SOT_SMD:SOT-223-3_TabPin2","1",""
"U5","D5V0H1B2LP-7B","https://www.diodes.com/assets/Datasheets/D5V0H1B2LP.pdf","footprints:D5V0H1B2LP_7B","1",""

## KiCad design hats/new_imu_hat/Xplore ERC IMU HAT.kicad_pcb

Board: 4 copper layers, 31.0 x 30.3 mm, 29 parts (14 on the bottom side), 19 nets.

Parts:
C1: 1uF; C_0402_1005Metric
C2: 2.2uF; C_0402_1005Metric
C3, C4: 4.7nF; C_0402_1005Metric
C5: 100nF; C_0402_1005Metric
CR1, CR2: PESD2CANFD27V-TR; SOT23_PESD2_NEX
CR3, CR4, CR5, CR6, CR7, CR8: SP3205-01ETG; SDO_SOD882_LTF
G1: Xplore_Logo; Xplore_Logo_X_only_5mm
J1: BM08B-GHS-TBT; CONN_BM08B-GHS-TBT_JST
J2, J5: 5025850670; CON_5025850670
J3: BM04B-GHS-TBT; CONN_BM04B-GHS-TBT_JST
J4: Hat_connector_hole
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R3, R4, R7: 60R; R_0603_1608Metric
R2: 10k; R_0402_1005Metric
R5, R6: 4k7; R_0201_0603Metric
U1: LT3960JMSE-PBF; LT3960
U2: D5V0H1B2LP-7B; D5V0H1B2LP_7B

Connections:
+3v3: C2.1, J1.1, J3.1, J4.2 (3.3V), R5.2, R6.2, U1.8 (VCC)
+5V: C1.1, C5.2, J4.15 (5V), J4.16 (5V), J5.3, R2.2, U1.6 (VIN), U2.1
/CANSCL+: CR1.1, J5.4, R1.1, U1.4 (CANSCLH)
/CANSCL-: CR1.2, J5.5, R3.1, U1.5 (CANSCLL)
/CANSDA+: CR2.1, J5.2, R4.2, U1.2 (CANSDAH)
/CANSDA-: CR2.2, J5.1, R7.2, U1.1 (CANSDAL)
/DRDY: CR8.1, J1.7, J2.6, J4.14 (GPIO_6)
/INT1: CR4.1, J1.2, J2.1, J4.9 (GPIO_1)
/INT2: CR3.1, J1.3, J2.2, J4.10 (GPIO_2)
/INT3: CR6.1, J1.4, J2.3, J4.11 (GPIO_3)
/INT4: CR5.1, J1.5, J2.4, J4.12 (GPIO_4)
/MAG_INT: CR7.1, J1.6, J2.5, J4.13 (GPIO_5)
/SCL: J3.2, J4.7 (I2C_SCL), R5.1, U1.9 (SCL)
/SDA: J3.3, J4.8 (I2C_SDA), R6.1, U1.10 (SDA)
/SLD_PIN: JP1.2 (B), U1.7 (EN/MODE)
/SLD_R2: JP1.1 (A), R2.1
GND: C1.2, C2.2, C3.2, C4.2, C5.1, CR1.3, CR2.3, CR3.2, CR4.2, CR5.2, CR6.2, CR7.2, CR8.2, J1.8, J2.7, J2.8, J3.4, J4.1 (GND), J5.6, J5.7, J5.8, U1.3 (GND), U1.11 (GND), U2.2
unnamed: C3.1, R1.2, R3.2
unnamed: C4.1, R4.1, R7.1

## KiCad design Power/GEOX/rev2/SMPS_legged_robot_module/SMPS_legged_robot_module.kicad_pcb

Board: 6 copper layers, 168.7 x 58.0 mm, 156 parts (25 on the bottom side), 83 nets.

Parts:
C401, C601, C603, C702, C715: 100n X7R 50V; C_0402_1005_DensityHigh
C602, C604, C708, C713, C718, C722, C723: 10n X7R 100V; C_0402_1005_DensityHigh
C607: 1u X7R 25V; C_0603_1608_DensityHigh
C701, C706, C707, C714, C731, C732, C901, C903, C906, C907: 10uF X7R 100V; C_1210_3225_DensityHigh
C703, C720, C725: 1n X7R 100V; C_0402_1005_DensityHigh
C704, C705, C729, C730: 120u CAN 50V; Hybrid_G_VP
C709, C712: 33p X7R 25V; C_0402_1005_DensityHigh
C710, C711: 6.8n X7R 25V; C_0402_1005_DensityHigh
C716, C726: 2.2u X7R 25V; C_0603_1608_DensityHigh
C717, C724: 4.7u X5R 25V; C_0402_1005_DensityHigh
C902: 4u7 X7R 100V; C_1206_3216_DensityHigh
C904, C905: 56u CAN 63V; Hybrid_G_VP
D601, D602, D703: DFLS1100-7; Diodes_Inc.-PowerDI123-03_2017-0-MFG
D603, D605: SMAJ28A; D_SMA
D604, D606: SMAJ33A; D_SMA
D701, D702: GREEN; LED_0603_1608Metric
FM701, FM702, FM703, FM704, FM705, FM706: Fiducial; Fiducial_1mm_Mask2mm
H801, H802: M2 (2.2mm); MountingHole_2.2mm_M2_Pad_Via
IC601, IC602: LTC4372CMS8#TRPBF; SOP65P490X110-8N
IC701: LTC3889EUKG#PBF; QFN50P700X800X80-53N-D
J401: 10159559-410221RLF; 10159559410221RLF
L701, L702: 4,7uH; PQ2617BHA4R7K
L901: 1u XEL6060-102MEB; XEL6060102MEC
NT601, NT602, NT603, NT604, NT605, NT606: NetTie_2; NetTie-2_SMD_Pad0.2mm
Q601, Q602, Q603, Q604: BSC016N06NSATMA1; PG-TDSON-8_INF
Q701, Q702, Q705, Q706: IPG20N06S4L26AATMA1; Infineon-IPG20N06S4L-26A-Manufacturer_Recommended
Q703, Q704: PMBT3906,215; SOT-23
Q707, Q708: NX3020NAK,215; SOT-23-3
R601, R603: 10R 1% 1/8W; R_0805_2012_DensityHigh
R602, R604, R727, R728: 1k 1% 1/10W; R_0603_1608_DensityHigh
R701: 5k 1% 1/16W; R_0402_1005_DensityHigh
R702, R703, R704, R705, R706, R707, R708, R709, R710, R711: 10k 1% 1/16W; R_0402_1005_DensityHigh
R712, R713, R714, R715, R716, R718, R719, R720, R721, R722: R; R_0402_1005_DensityHigh
R717, R729: 3m 1% 3W; RESC6432X135N
R723, R724, R730, R731, R901, R902: 10R 1% 1/8W; R_0402_1005_DensityHigh
R725: 2m 1% 3W; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R726, R732, R733, R734, R735, R738, R739: 2R 1% 1/8W; R_0402_1005_DensityHigh
R736, R737: 470R 1% 1/8W; R_0402_1005_DensityHigh
TP401: FAULT0; TestPoint_Pad_D0.5mm_Front
TP402: FAULT1; TestPoint_Pad_D0.5mm_Front
TP403: SDA; TestPoint_Pad_D0.5mm_Front
TP404: SCL; TestPoint_Pad_D0.5mm_Front
TP405: RUN0; TestPoint_Pad_D0.5mm_Front
TP406: RUN1; TestPoint_Pad_D0.5mm_Front
TP407: ALERT; TestPoint_Pad_D0.5mm_Front
TP408: +VBAT_IN; TestPoint_Pad_D0.5mm_Front
TP409: +12V; TestPoint_Pad_D0.5mm_Front
TP410, TP413, TP414: GND; TestPoint_Pad_D0.5mm_Front
TP411: MVA; TestPoint_Pad_D0.5mm_Front
TP412: MVB; TestPoint_Pad_D0.5mm_Front
TP701: VIN; TestPoint_Pad_D0.5mm_Front
TP702: SW0; TestPoint_Pad_D0.5mm_Front
TP703: SW1; TestPoint_Pad_D0.5mm_Front
TP704: 2V5LTC; TestPoint_Pad_D0.5mm_Back
TP705: 3V3LTC; TestPoint_Pad_D0.5mm_Back
TP706: DRVCC; TestPoint_Pad_D0.5mm_Back
TP707: MVB_OUT; TestPoint_Pad_D0.5mm_Front
TP708: MVA_OUT; TestPoint_Pad_D0.5mm_Front
TP709: VIN_MOS; TestPoint_Pad_D0.5mm_Front
TP710: SW0_L; TestPoint_Pad_D0.5mm_Front
TP711: SW1_L; TestPoint_Pad_D0.5mm_Front
kibuzzard-66485E02: G***; kibuzzard-66485E02
kibuzzard-66485E57: G***; kibuzzard-66485E57
kibuzzard-66485E80: G***; kibuzzard-66485E80

Connections:
+2V5LTC: C726.2, IC701.27 (VDD25), R712.1, R713.1, R714.1, R715.1, R716.1, TP704.1
+3.3VLTC: C716.2, IC701.30 (VDD33), R701.2, R702.2, R703.2, R704.2, R705.2, R706.2, R707.2, R708.2, R709.2, R710.2, R711.2, TP705.1
+12V: C401.1, C717.2, D703.1 (K), IC701.43 (EXTVCC), J401.S10, R736.1, R737.1, TP409.1
/Project Architecture/+VBAT_Filtered: C903.1, C904.1, C905.1, C906.1, C907.1, L901.2, NT602.1, R725.1, R726.2
/Project Architecture/+VBAT_IN: C901.1, C902.1, J401.P1, L901.1, TP408.1
/Project Architecture/MVA_FILTERED: IC601.1 (OUT), J401.P3, Q602.1 (D), TP411.1
/Project Architecture/MVB_FILTERED: IC602.1 (OUT), J401.P4, Q604.1 (D), TP412.1
/Project Architecture/Power - Connector /MVA_SHDN: IC601.8 (SHDN), J401.S8
/Project Architecture/Power - Connector /MVB_SHDN: IC602.8 (SHDN), J401.S9
/Project Architecture/Power - Connector /RUN0: IC701.19 (RUN0), J401.S4, R705.1, TP405.1
/Project Architecture/Power - Connector /RUN1: IC701.20 (RUN1), J401.S2, R704.1, TP406.1
/Project Architecture/Power - Connector /SCL: IC701.14 (SCL), J401.S1, R710.1, TP404.1
/Project Architecture/Power - Connector /SDA: IC701.15 (SDA), J401.S3, R711.1, TP403.1
/Project Architecture/Power - Connector /~ALERT: IC701.16 (~ALERT), J401.S5, R709.1, TP407.1
/Project Architecture/Power - Connector /~FAULT0: IC701.17 (~FAULT0), J401.S7, R708.1, TP401.1
/Project Architecture/Power - Connector /~FAULT1: IC701.18 (~FAULT1), J401.S6, R707.1, TP402.1
/Project Architecture/Power - Converter/DRVCC: C607.2, C724.2, D601.2 (A), D602.2 (A), IC701.44 (DRVCC), TP706.1
/Project Architecture/Power - Converter/MVA_OUT: C704.1, C705.1, C706.1, C707.1, D603.2 (A2), IC601.4 (IN), IC701.7 (VSENSE0+), NT606.1, Q601.1 (D), R717.2, TP708.1
/Project Architecture/Power - Converter/MVB_OUT: C729.1, C730.1, C731.1, C732.1, D605.2 (A2), IC602.4 (IN), IC701.35 (VSENSE1+), NT604.1, Q603.1 (D), R729.2, TP707.1
/Project Architecture/Power - Converter/PGOOD0: IC701.34 (PGOOD0), Q707.1 (G), R702.1
/Project Architecture/Power - Converter/PGOOD1: IC701.33 (PGOOD1), Q708.1 (G), R703.1
/Project Architecture/Power - Converter/SHARE_CLK: IC701.29 (SHARE_CLK), R706.1
/Project Architecture/Power - Converter/SW0: C702.2, IC701.1 (SW0), L701.1, Q701.3 (S), Q702.1 (D), TP702.1
/Project Architecture/Power - Converter/SW0_L: L701.2, NT605.1, R717.1, TP710.1
/Project Architecture/Power - Converter/SW1: C715.2, IC701.39 (SW1), L702.2, Q705.3 (S), Q706.1 (D), TP703.1
/Project Architecture/Power - Converter/SW1_L: L702.1, NT603.1, R729.1, TP711.1
/Project Architecture/Power - Converter/SYNC: IC701.13 (SYNC), R701.1
/Project Architecture/Power - Converter/VIN: C718.2, C722.2, C723.2, IC701.48 (VIN), R726.1, TP701.1
/Project Architecture/Power - Converter/VIN_MOS: C701.1, C714.1, NT601.1, Q701.1 (D), Q705.1 (D), R725.2, TP709.1
/Project Architecture/Power - Converter/shuntA+: NT606.2, R724.2
/Project Architecture/Power - Converter/shuntA-: NT605.2, R723.2
/Project Architecture/Power - Converter/shuntB+: NT604.2, R731.2
/Project Architecture/Power - Converter/shuntB-: NT603.2, R730.2
/Project Architecture/Power - Converter/shuntIn+: NT601.2, R728.1
/Project Architecture/Power - Converter/shuntIn-: NT602.2, R727.1
GND: C401.2, C601.2, C602.1, C603.2, C604.1, C607.1, C701.2, C704.2, C705.2, C706.2, C707.2, C708.1, C709.1, C710.1, C711.1, C712.1, C713.1, C714.2, C716.1, C717.1, C718.1, C724.1, C726.1, C729.2, C730.2, C731.2, C732.2, C902.2, C904.2, C905.2, C906.2, C907.2, D604.2 (A2), D606.2 (A2), D703.2 (A), IC601.6 (GND), IC602.6 (GND), IC701.8 (VSENSE0-), IC701.26 (PHAS_CFG), IC701.28 (WP), IC701.53 (GND), J401.P2, Q702.3 (S), Q703.1 (B), Q703.3 (C), Q704.1 (B), Q704.3 (C), Q706.3 (S), Q707.2 (S), Q708.2 (S), R718.2, R719.2, R720.2, R721.2, R722.2, R901.1, R902.1, TP410.1, TP413.1, TP414.1
unnamed: C602.2, R602.2
unnamed: C604.2, R604.2
unnamed: C901.2, R901.2
unnamed: C903.2, R902.2
unnamed: C715.1, D601.1 (K), R738.1
unnamed: C702.1, D602.1 (K), R739.1
unnamed: D603.1 (A1), D604.1 (A1)
unnamed: D605.1 (A1), D606.1 (A1)
unnamed: D701.2 (A), R736.2
unnamed: D701.1 (K), Q707.3 (D)
unnamed: D702.2 (A), R737.2
unnamed: D702.1 (K), Q708.3 (D)
unnamed: IC601.2 (GATE), Q602.2 (G), R601.2, R602.1
unnamed: C601.1, IC601.5 (INTVCC)
unnamed: IC601.3 (SOURCE), Q601.3 (S), Q602.3 (S)
unnamed: IC602.2 (GATE), Q604.2 (G), R603.2, R604.1
unnamed: C603.1, IC602.5 (INTVCC)
unnamed: IC602.3 (SOURCE), Q603.3 (S), Q604.3 (S)
unnamed: C720.1, C722.1, IC701.47 (IIN+), R727.2
unnamed: C720.2, C723.1, IC701.46 (IIN-), R728.2
unnamed: IC701.21 (ASEL0), R714.2, R720.1
unnamed: IC701.22 (ASEL1), R715.2, R721.1
unnamed: IC701.25 (FREQ_CFG), R716.2, R722.1
unnamed: C709.2, IC701.12 (ITH0)
unnamed: C712.2, IC701.31 (ITH1)
unnamed: C710.2, IC701.11 (ITHR0)
unnamed: C711.2, IC701.32 (ITHR1)
unnamed: C708.2, IC701.6 (TSNS0), Q703.2 (E)
unnamed: C713.2, IC701.36 (TSNS1), Q704.2 (E)
unnamed: IC701.23 (VOUT0_CFG), R712.2, R718.1
unnamed: IC701.24 (VOUT1_CFG), R713.2, R719.1
unnamed: IC701.50 (BG0), R732.2
unnamed: IC701.52 (BOOST0), R739.2
unnamed: C703.1, IC701.4 (ISENSE0+), R723.1
unnamed: C703.2, IC701.5 (ISENSE0-), R724.1
unnamed: IC701.2 (TG0), R733.2
unnamed: IC701.42 (BG1), R734.2
unnamed: IC701.40 (BOOST1), R738.2
unnamed: C725.1, IC701.9 (ISENSE1+), R730.1
unnamed: C725.2, IC701.10 (ISENSE1-), R731.1
unnamed: IC701.38 (TG1), R735.2
unnamed: Q601.2 (G), R601.1
unnamed: Q603.2 (G), R603.1
unnamed: Q701.2 (G), R733.1
unnamed: Q702.2 (G), R732.1
unnamed: Q705.2 (G), R735.1
unnamed: Q706.2 (G), R734.1

## KiCad design Power/ElonMux/ElonMux.kicad_pcb

File Power/ElonMux/README.md:

<p align="center" width="100%">
  <picture>
    <source media="(prefers-color-scheme: dark)" srcset="./Logos/ElonMuxLight.png">
    <source media="(prefers-color-scheme: light)" srcset="./Logos/ElonMuxDark.png">
    
  </picture>
</p>

<h1 align="center">ElonMux</h1>

ElonMux was designed for EPFL [Xplore's](https://github.com/EPFLXplore) rover in the context of the European Rover Challenge. This board is capable to power the rover while simultaneously charging it's battery. The user have to be able to plug and unplug the power supply from the rover without shuting down/rebooting the load, requiring fast switching times. 
The system will always try to use the external power supply as the primary power source for the rover, but will default to the battery if it is not availaible.

| Info       |                 |
|------------|-----------------|
| Designer   | Théo           |
| Date       | Oct. - Nov. 2024 |
| Project    | ERC            |

***

## SPECIFICATIONS

| Parameter | ElonMux V1.0 | 
| --- | --- |
| Voltage Input | 10-33V |
| Continuous Supply Current | 30A |
| Continuous Discharge Current | 30A |
| Continuous Charge Current | 7A |
| Mass | TBD |
| Communication | USB 2.0 / JTAG |
| MCU | ESP32-S3FN8 |
| Dimensions | 100x70x13mm |

***

## DIRECTORY STRUCTURE

```
ElonMux
├── Computations        # Computation sheets an simulation performed
├── Datasheets          # Datasheet of major components
├── Images              # Pictures and screenshots
├── lib
    |── 3d_models       # Component 3D models
    |── lib_fp          # Footprint libraries
    └── lib_sym         # Symbol libraries
├── Logos               # Xplore and ElonMux logos
├── Manufacturing & BOMs
│   |── Assembly        # Position files, BOM, assembly document
|   |   └── ibom        # HTML BOM
|   └── Fabrication     # Fabrication document and testpoints positions
|       └── Gerbers     # Gerbers
├── Schematic           # PDF of schematic
├── STEP                # Step file of the board
└── Templates           # Title block templates

```

***

## FIRMWARE

TBI

***

## CREDITS

Schematic template & project structure is hugely inspired by the work of Vincent Nguyen on its [Λ M U L E T](https://github.com/EPFLXplore/XRE_LeggedRobot_HW/tree/master/amulet_controller) controler.

***

## PHOTOS

Notes on the sheet:
3D render of your PCB here (Bottom View)
3D render of your PCB here (Top View)
Metadata can be set in File → Schematic Setup → Project → Text Variables
DESIGN NOTE: Example text for informational design notes.
LAYOUT NOTE: Example text for critical layout guidelines.
DESIGN NOTE: Example text for cautionary design notes.
DESIGN NOTE: Example text for debug notes.
DESIGN NOTE: Example text for critical design notes.
BOTTOM VIEW
...........................................
Schematic based on Vincent Nguyen's Template. Many thanks to him for making this public.
RELEASED - A board with this schematic has been sent to production.
Page
TOP VIEW
Interface - Connectors
Sensing - Battery
Power - Power Path
Not fitted components are marked as
Index
Revision History
PRELIMINARY - Close to final schematic.
${VARIANT} ${RELEASE_DATE}
MCU - Unit
${CURRENT_DATE}
Variant: ${VARIANT}
Rev ${REVISION}
Power - Connectors
User - LED Indicators
${BOARD_NAME}
DRAFT - Very early stage of schematic, ignore details.
Power - Generation
Block Diagram
Board designed for EPFL Xplore's rover in the context of the European Rover Challenge.
Cover Page
NOTES
Power - Sequencing
Project Architecture
CHECKED - There shouldn't be any mistakes. Contact the engineer if you find any.
DESIGN CONSIDERATIONS
Power - Charger

Notes on the sheet:
Continuous discharge current:
The purpose of this board is to be able to charge a battery and power the main load simultaneously. The user have to be able to plug and unplug the power supply from the rover without shuting down/rebooting the load, requiring fast switching times. The system will always try to use the external pow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
Continuous charge current:
Input voltage (battery&supply):
30A
[${#}] ${TITLE}
Target specifications:
10V - 36V
Continuous supply current:
Made in draw.io

Notes on the sheet:
- _________________________________ - _________________________________ - _________________________________ - _________________________________ - _________________________________ - _________________________________ - _________________________________ - _________________________________ - _________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
DD.MM.YYYY - xxx Revision Variant: xxx
[${#}] ${TITLE}
- Added the pin 29 on the ESP32 that was missing. - Added test points for the status pins of the other ICs. - Improved brightness of debug LED. - Switch to differential pairs for shunt resistors. - Reduced BOM size by using the same 8 N-MOSFETs - Connecting some debug GPIO to Ics (ex: VALID1/2). - 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
15.10.2024 - Xplore Schematic Review Variant: V1.0 Draft -> V1.0 Preliminary
