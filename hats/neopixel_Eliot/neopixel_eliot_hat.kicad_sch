File: hats/neopixel_Eliot/neopixel_eliot_hat.kicad_sch (KiCad schematic)
At the start: 60 parts, among them J1 B3B-XH-A(LF)(SN), J2 Hat_connector, J202 Conn_Picoblade_JST_DEBUG, J301 USB_B_Micro, Q1 SS8050-G, Q2 SS8050-G, Q301 PJA3405, U1 ESP32-PICO-D4, U2 AMS1117, U301 SRV05-4A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

Commit message: Neopixel v2.2 with BOM and Gerber/Drill files
Parts:
- removed C17, C18, C5, C6, C7: 0.1uF, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, symbol Device:C_Small
- removed C2: 0.1uF, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- removed C303: 0.1uF, Capacitor_SMD:C_0603_1608Metric, symbol Device:C_Small
- removed C304: 4.7uF, Capacitor_SMD:C_0603_1608Metric, symbol Device:C_Small
- added C1: 4.7uF, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added C2 (x5): 0.1uF, Capacitor_SMD:C_0603_1608Metric, symbol Device:C_Small
- added C2 (x2): 0.1uF, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- C1: link (none) -> https://eu.mouser.com/ProductDetail/Samsung-Electro-Mechani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
- C14: footprint Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder -> Capacitor_SMD:C_0603_1608Metric; Distributor (none) -> Mouser; link (none) -> https://eu.mouser.com/ProductDetail/Murata-Electronics/GRM1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
- C15: footprint Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder -> Capacitor_SMD:C_0805_2012Metric; Distributor (none) -> Mouser; link (none) -> https://eu.mouser.com/ProductDetail/Samsung-Electro-Mechani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
- C2: link (none) -> https://eu.mouser.com/ProductDetail/TAIYO-YUDEN/TMK107B7104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
- C3: Distributor ref TMK107B7104KAHT -> MBAST168AB7105KTNA01; Manufacturer ref 963-TMK107B7104KAHT -> 963-BAST168AB7105KT; link (none) -> https://eu.mouser.com/ProductDetail/TAIYO-YUDEN/MBAST168AB7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
- C303: Distributor (none) -> Mouser; link (none) -> https://eu.mouser.com/ProductDetail/TAIYO-YUDEN/UMK105B7104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
- C304: Distributor (none) -> Mouser; link (none) -> https://eu.mouser.com/ProductDetail/Samsung-Electro-Mechani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
- D2: Distributor (none) -> Mouser; link (none) -> https://eu.mouser.com/ProductDetail/ams-OSRAM/LS-L296-N2Q1-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
- D204: Digikey ref 497-7231-1-ND -> (none); Distributor (none) -> Mouser; link (none) -> https://eu.mouser.com/ProductDetail/STMicroelectronics/ESDA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
- D301: Distributor (none) -> Mouser; link (none) -> https://eu.mouser.com/ProductDetail/Micro-Commercial-Compon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
- F301: link (none) -> https://eu.mouser.com/ProductDetail/Littelfuse/0805L075SLYR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
- J1, J202: Distributor (none) -> Digikey; link (none) -> https://www.digikey.com/en/products/detail/jst-sales-americ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
- J301: Distributor (none) -> Digikey; link (none) -> https://www.digikey.com/en/products/detail/molex/1050170001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
- LV1: Distributor (none) -> Mouser; link (none) -> https://www.mouser.ch/ProductDetail/Texas-Instruments/SN74L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
- Q1, Q2: Distributor (none) -> Digikey; link (none) -> https://www.digikey.com/en/products/detail/comchip-technolo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
- Q301: link (none) -> https://www.digikey.com/en/products/detail/panjit-internati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
- R1: link (none) -> https://www.mouser.ch/ProductDetail/Panasonic/ERA-3ARB2212V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
- R12: footprint Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder -> Resistor_SMD:R_0603_1608Metric; Distributor (none) -> Mouser; link (none) -> https://www.mouser.ch/ProductDetail/Panasonic/ERA-3AED202V?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
- R2: footprint Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder -> Resistor_SMD:R_0603_1608Metric; Distributor (none) -> Mouser; link (none) -> https://www.mouser.ch/ProductDetail/Vishay-Dale/CRCW060310K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
- R2, R3: link (none) -> https://www.mouser.ch/ProductDetail/Vishay-Dale/CRCW060310K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
- R2: link (none) -> https://www.mouser.ch/ProductDetail/Panasonic/ERA-3AEB47R5V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
- R20: Distributor (none) -> Mouser; link (none) -> https://www.mouser.ch/ProductDetail/Panasonic/ERJ-S02D1002X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
- R204, R206, R207: Distributor (none) -> Digikey; link (none) -> https://www.digikey.com/en/products/detail/te-connectivity-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
- R22: link (none) -> https://www.mouser.ch/ProductDetail/Panasonic/ERA-2ARC102X?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
- R3: link (none) -> https://www.mouser.ch/ProductDetail/Panasonic/ERA-3AED4990V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
- R3: link (none) -> https://www.mouser.ch/ProductDetail/Panasonic/ERA-3APB222V?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
- R3: footprint Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder -> Resistor_SMD:R_0603_1608Metric; Distributor (none) -> Mouser; link (none) -> https://www.mouser.ch/ProductDetail/Panasonic/ERA-3AED101V?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
- U1: link (none) -> https://www.digikey.com/en/products/detail/espressif-system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
- U2: link (none) -> https://www.digikey.ch/en/products/detail/evvo/AMS1117-3-3/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
- U301: link (none) -> https://www.digikey.ch/en/products/detail/smc-diode-solutio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
- U303: link (none) -> https://www.digikey.ch/en/products/detail/silicon-labs/CP21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
Connections:
- net +3V3: now also C2.1, C2.1, C2.1, C2.2, C2.2
- net +5V_MCU: now also C1.1, C2.1
- net EN: now also C2.1
- net GND: now also C1.2, C2.1, C2.1, C2.2, C2.2, C2.2, C2.2, C2.2

Commit message: Updated bom
Parts:
- D301: link https://eu.mouser.com/ProductDetail/Micro-Commercial-Compon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 -> https://www.digikey.ch/en/products/detail/micro-commercial-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
- F301: link https://eu.mouser.com/ProductDetail/Littelfuse/0805L075SLYR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 -> https://www.digikey.ch/en/products/detail/littelfuse-inc/08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
- R12: value 2K(1%) -> 50R; link https://www.mouser.ch/ProductDetail/Panasonic/ERA-3AED202V?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 -> https://www.mouser.ch/ProductDetail/Vishay-Draloric/TNPU060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
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "link" "https://eu.mouser.com/ProductDetail/Littelfuse/0805L075SLYR?qs=C%2F0tY%2F%2FqZe89Ht%2FbgKOotQ%3D%3D" (at 90.17 203.3524 0)
+    (property "link" "https://www.digikey.ch/en/products/detail/littelfuse-inc/0805L075SLYR/2764997" (at 90.17 203.3524 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "link" "https://eu.mouser.com/ProductDetail/Micro-Commercial-Components-MCC/SMF5.0CA-TP?qs=y6ZabgHbY%252Bx5chrSGzaXjw%3D%3D" (at 42.7482 221.1324 0)
+    (property "link" "https://www.digikey.ch/en/products/detail/micro-commercial-co/SMF5-0CA-TP/7320159" (at 42.7482 221.1324 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "2K(1%)" (at 359.2322 210.1088 0)
+    (property "Value" "50R" (at 357.9622 209.9564 0)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "link" "https://www.mouser.ch/ProductDetail/Panasonic/ERA-3AED202V?qs=sGAEpiMZZMtlubZbdhIBINnjttWTECnXPYH118Z5ZyA%3D" (at 354.1522 209.4738 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "link" "https://www.mouser.ch/ProductDetail/Vishay-Draloric/TNPU060350R0BZEN00?qs=t7xnP681wgWwtWlrkwxO6w%3D%3D" (at 354.1522 209.4738 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: start of revision, changed the i2c to UART and usb micro to usb c
Parts:
- removed J301: USB_B_Micro, 0_connectors:USB_Micro-B_Molex-105017-0001, symbol 0_connectors:USB_B_Micro
- removed R3 (x2): 2k2, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added J3: USB_C_Receptacle, Connector_USB:USB_C_Receptacle_Molex_105450-0101, symbol Connector:USB_C_Receptacle
- added R4, R5: 5.1k, symbol Device:R
Connections:
- net D+: now also J3.A6 (D+), J3.B6 (D+)
- net D-: now also J3.A7 (D-), J3.B7 (D-)
- net GND: now also J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), R4.2, R5.2
- net MCU_GPIO1: no longer J2.9 (GPIO_1)
- net MCU_GPIO2: no longer J2.10 (GPIO_2)
- net MCU_GPIO3: no longer J2.11 (GPIO_3)
- net MCU_GPIO4: no longer J2.12 (GPIO_4)
- net VBUS: now also J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
- net I2C_SCL: no longer names the net of U1.39 (IO22)
- net I2C_SCL: no longer J2.7 (I2C_SCL)
- net I2C_SDA: no longer names the net of U1.42 (IO21)
- net I2C_SDA: no longer J2.8 (I2C_SDA)
- new net: J3.A5 (CC1), R4.1
- new net: J3.B5 (CC2), R5.1
- no-connect marks 34 -> 48
Other:
- note added: "Note to self: swap routing in pcb layout"
- note added: "Replace by USB-c and pull down to ground (see link)"
- note added: "USB C & USB-UART"
- note removed: "USB Micro & USB-UART"
- moved on the sheet: C3, D301, F301, Q301, R1, R2, TP2, U301

Commit message: added power MUX and made space for e fuse
Parts:
- removed F301: 0805L075SLYR, Fuse:Fuse_0805_2012Metric, symbol Device:Polyfuse_Small
- added IC1: TPS2116DRLR, SOTFL50P160X60-8N, symbol SamacSys_Parts:TPS2116DRLR
Connections:
- net +5V_MCU: now also IC1.3 (VIN1), IC1.4 (PR1), IC1.5 (MODE); no longer C15.1, U2.3 (VI)
- net GND: now also IC1.1 (GND)
- net VBUS_REV: now also IC1.6 (VIN2)
- new net Vout_MUX: C15.1, IC1.2 (VOUT_1), U2.3 (VI)
- no-connect marks 48 -> 50
Other:
- note added: "add efuse <"
- note added: "power mux"
- moved on the sheet: C3, C303, C304, Q1, Q2, R1, R2, R20, R22, TP2, TP6, TP7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
