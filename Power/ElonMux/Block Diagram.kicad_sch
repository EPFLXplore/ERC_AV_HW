File: Power/ElonMux/Block Diagram.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Implemented BQ battery charger
