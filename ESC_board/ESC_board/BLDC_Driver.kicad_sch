File: ESC_board/ESC_board/BLDC_Driver.kicad_sch (KiCad schematic)
At the start: 47 parts

Commit message: Added ESC schematic and board layout
Parts:
- removed C?: C, symbol Device:C
- removed C? (x3), C_bypass? (x2): ~, symbol Device:C_Small
- removed JP? (x2): SolderJumper_3_Open, symbol Jumper:SolderJumper_3_Open
- removed Q? (x3): Q_NMOS_DGS, symbol Device:Q_NMOS_DGS
- removed R? (x3): R, symbol Device:R
- removed R? (x2): R_Small, symbol Device:R_Small
- removed R? (x2): R, symbol Device:R_Small
- removed TP?: TestPoint, symbol Connector:TestPoint
- added C41, C44, C48: 0.1uF, Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder, symbol Device:C_Small
- added C46: 10uF, Capacitor_SMD:CP_Elec_5x5.8, symbol Device:C_Polarized_Small_US
- added C51: 1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C_Small
- added C_bypass1, C_bypass2: 0.1uF, Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder, symbol Device:C_Small
- added D10, D2, D3, D4, D5, D6, D7, D8, D9: BAT41ZFILM, Diode_SMD:D_SOD-523, symbol Device:D_Schottky_Small
- added Q2, Q4, Q6: TPH2R306NH1,LQ, lib:TPH2R306NH1LQ, symbol Device:Q_NMOS_DGS
- added R10, R11, R4, R5, R7, R8: 10R, Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder, symbol Device:R_Small
- added R12, R13: 5mR, Resistor_SMD:R_2010_5025Metric_Pad1.40x2.65mm_HandSolder, symbol Device:R_Small
- C42, C45, C47: renamed from C?; value ~ -> 0.1uF; footprint (none) -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C43: renamed from C?; value ~ -> 0.1uF; footprint (none) -> Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Voltage 16V -> 60V
- C49: renamed from C?; value ~ -> 47nF; footprint (none) -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C50: renamed from C?; value ~ -> 1uF; footprint (none) -> Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- C52: renamed from C?; value C -> 0.1uF; footprint (none) -> Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
- C_bypass3: renamed from C_bypass?; value ~ -> 0.1uF; footprint (none) -> Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; Voltage 48V -> 60V
- IC2: renamed from IC?; footprint (none) -> Package_DFN_QFN:Texas_S-PVQFN-N40_EP4.15x4.15mm_ThermalVias
- J5: renamed from J?; footprint (none) -> TerminalBlock:TerminalBlock_Altech_AK300-3_P5.00mm
- JP1: renamed from JP?; footprint (none) -> Jumper:SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm_NumberLabels
- Q1, Q3, Q5: renamed from Q?; value Q_NMOS_DGS -> TPH2R306NH1,LQ; footprint (none) -> lib:TPH2R306NH1LQ
- R14: renamed from R?; value R -> 5mR; footprint (none) -> Resistor_SMD:R_2010_5025Metric_Pad1.40x2.65mm_HandSolder; ID (none) -> TLR2HWDTE5L00F75
- R15: renamed from R?; value R -> 10k; footprint (none) -> Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
- R6: renamed from R?; value R_Small -> DNP; footprint (none) -> Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
- R9: renamed from R?; value R -> 10k; footprint (none) -> Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
- R_Gate1, R_Gate2, R_Gate3, R_Gate4, R_Gate5, R_Gate6: renamed from R?; value R -> 10R; footprint (none) -> Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
- TH1: renamed from TH?; value Thermistor_NTC -> 47k; footprint (none) -> Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; ID (none) -> ERT-J1VP473FM
- gave numbers to parts that had none: 3
Connections:
- net GNDA is gone; now on net GND: C52.2, R15.2
- net VDDA is gone; now on net +3V3: TH1.1
- net VDRAIN is gone; now on net Vdrive: IC2.6 (VDRAIN)
- net GHA: now also R_Gate1.1, D2.1 (K)
- net GHB: now also R_Gate4.1, D6.1 (K)
- net GHC: now also R_Gate5.1, D8.1 (K)
- net GLA: now also R_Gate2.1, D3.1 (K)
- net GLB: now also R_Gate3.1, D5.1 (K)
- net GLC: now also R_Gate6.1, D9.1 (K)
- net INHA: no longer R_Gate1.1
- net INHB: no longer R_Gate4.1
- net INHC: no longer R_Gate5.1
- net INLA: no longer R_Gate2.1
- net INLB: no longer R_Gate3.1
- net INLC: no longer R_Gate6.1
- net SAN: now also R12.2, R5.2; no longer U2.1 (-)
- net SAP: now also Q2.1 (D), R12.1, R4.2; no longer U2.8 (+)
- net SBN: now also R13.2, R8.2; no longer U3.1 (-)
- net SBP: now also Q4.1 (D), R13.1, R7.2; no longer U3.8 (+)
- net SCN: now also R11.2; no longer U4.1 (-)
- net SCP: now also Q6.1 (D), R10.2; no longer U4.8 (+)
- net Vdrive: now also C43.1, C50.2, C_bypass3.1, IC2.5 (VM), C46.1, C_bypass1.1, C_bypass2.1; no longer C_bypass3.2, IC2.38 (VIN)
- net at R_Gate6.2: now also D10.1 (K), D9.2 (A), Q6.2 (G)
- net GND: now reaches IC2.39 (NSHDN)
- net GND: now also C42.2, C43.2, C45.2, C47.2, C_bypass3.2, IC2.1 (PGND), IC2.10 (SLA), IC2.11 (SLB), IC2.18 (SLC), IC2.19 (GND), IC2.26 (AGND), IC2.34 (BGND)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
- net at Q1.2 (G), R_Gate1.2: now also D2.2 (A)
- net at R_Gate2.2: now also D3.2 (A), D4.1 (K), Q2.2 (G)
- net at Q3.2 (G), R_Gate4.2: now also D6.2 (A)
- net MOT_FAULT: now reaches IC2.20 (NFAULT), R9.2
- net at Q5.2 (G), R_Gate5.2: now also D8.2 (A)
- net at R_Gate3.2: now also D5.2 (A), D7.1 (K), Q4.2 (G)
- net +3.3VP renamed +3V3
- net +3V3: now also C42.1, C45.1, C47.1, R9.1, U2.3 (REF2), U2.6 (V+), U3.3 (REF2), U3.6 (V+), U4.3 (REF2), U4.6 (V+), C51.1
- removed net +5V: C42.1, C42.2, C43.2, C45.1, C45.2, C47.1, C47.2, C_bypass3.1, IC2.1 (PGND), IC2.10 (SLA), IC2.11 (SLB), IC2.18 (SLC)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
- net CB: no longer names the net of IC2.35 (CB)
- net FB: no longer names the net of IC2.40 (FB)
- net SW: no longer names the net of IC2.36 (SW)
- removed net VCC: C43.1, C50.2, IC2.5 (VM), R9.1
- new net: C41.2, R5.1, U2.1 (-)
- new net: C41.1, R4.1, U2.8 (+)
- new net: C44.2, R8.1, U3.1 (-)
- new net: C44.1, R7.1, U3.8 (+)
- new net: C48.2, R11.1, U4.1 (-)
- new net: C48.1, R10.1, U4.8 (+)
- no-connect marks 2 -> 6
Other:
- note removed: "IDRIVE controls the output gate current of the DRV chip. Here, IDRIVE = HI-Z, Idriven = 240 ma (check [1] for more info)"
- moved on the sheet: C42, C43, C45, C47, C49, C50, C52, C_bypass3, IC2, J5, JP1, Q1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

Commit message: Changed power supply and small adjustments added
Parts:
- C41, C44, C48, C52: value 0.1uF -> (none); footprint Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder -> (none)
- C42, C45, C47: value 0.1uF -> (none); footprint Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder -> (none)
- C43: value 0.1uF -> (none); footprint Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder -> (none)
- C46: value 10uF -> (none); footprint Capacitor_SMD:CP_Elec_5x5.8 -> (none)
- C49: value 47nF -> (none); footprint Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder -> (none)
- C50, C51: value 1uF -> (none); footprint Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder -> (none)
- C_bypass1, C_bypass2, C_bypass3: value 0.1uF -> (none); footprint Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder -> (none)
- D10, D2, D3, D4, D5, D6, D7, D8, D9: value BAT41ZFILM -> (none); footprint Diode_SMD:D_SOD-523 -> (none)
- IC2: value ~ -> (none); footprint Package_DFN_QFN:Texas_S-PVQFN-N40_EP4.15x4.15mm_ThermalVias -> (none)
- J5: value Conn_01x03 -> (none); footprint TerminalBlock:TerminalBlock_Altech_AK300-3_P5.00mm -> (none)
- JP1: value SolderJumper_3_Open -> (none); footprint Jumper:SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm_NumberLabels -> (none)
- Q1, Q2, Q3, Q4, Q5, Q6: value TPH2R306NH1,LQ -> (none); footprint lib:TPH2R306NH1LQ -> (none)
- R10, R11, R4, R5, R7, R8, R_Gate1, R_Gate2, R_Gate3, R_Gate4, R_Gate5, R_Gate6: value 10R -> (none); footprint Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder -> (none)
- R12, R13, R14: value 5mR -> (none); footprint Resistor_SMD:R_2010_5025Metric_Pad1.40x2.65mm_HandSolder -> (none)
- R15: value 10k -> (none); footprint Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder -> (none)
- R6: value DNP -> (none); footprint Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder -> (none)
- R9: value 10k -> (none); footprint Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder -> (none)
- TH1: value 47k -> (none); footprint Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder -> (none)
- U2, U3, U4: value INA240A1D -> (none); footprint Package_SO:SOIC-8_3.9x4.9mm_P1.27mm -> (none)

Commit message: Checkpoint rev 1.0
Parts:
- C41, C44, C48, C52: value (none) -> 0.1uF; footprint (none) -> Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
- C42, C45, C47: value (none) -> 0.1uF; footprint (none) -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C43: value (none) -> 0.1uF; footprint (none) -> Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- C46: value (none) -> 10uF; footprint (none) -> Capacitor_SMD:CP_Elec_5x5.8
- C49: value (none) -> 47nF; footprint (none) -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
- C50, C51: value (none) -> 1uF; footprint (none) -> Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- C_bypass1, C_bypass2, C_bypass3: value (none) -> 0.1uF; footprint (none) -> Capacitor_SMD:C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
- D10, D2, D3, D4, D5, D6, D7, D8, D9: value (none) -> BAT41ZFILM; footprint (none) -> Diode_SMD:D_SOD-523
- IC2: value (none) -> DRV8320; footprint (none) -> Package_DFN_QFN:Texas_S-PVQFN-N40_EP4.15x4.15mm_ThermalVias
- J5: value (none) -> Conn_01x03; footprint (none) -> TerminalBlock:TerminalBlock_Altech_AK300-3_P5.00mm
- JP1: value (none) -> SolderJumper_3_Open; footprint (none) -> Jumper:SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm_NumberLabels
- Q1, Q2, Q3, Q4, Q5, Q6: value (none) -> TPH2R306NH1,LQ; footprint (none) -> lib:TPH2R306NH1LQ
- R10, R11, R4, R5, R7, R8, R_Gate1, R_Gate2, R_Gate3, R_Gate4, R_Gate5, R_Gate6: value (none) -> 10R; footprint (none) -> Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
- R12, R13, R14: value (none) -> 5mR; footprint (none) -> Resistor_SMD:R_2010_5025Metric_Pad1.40x2.65mm_HandSolder
- R15: value (none) -> 10k; footprint (none) -> Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
- R6: value (none) -> DNP; footprint (none) -> Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
- R9: value (none) -> 10k; footprint (none) -> Capacitor_SMD:C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
- TH1: value (none) -> 47k; footprint (none) -> Resistor_SMD:R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
- U2, U3, U4: value (none) -> INA240A1D; footprint (none) -> Package_SO:SOIC-8_3.9x4.9mm_P1.27mm
