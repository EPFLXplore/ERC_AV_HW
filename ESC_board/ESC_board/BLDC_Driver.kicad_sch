File: ESC_board/ESC_board/BLDC_Driver.kicad_sch (KiCad schematic)
At the start: 1 part

Commit message: Updated localization files
Parts:
- removed IC?: (no value), symbol custom_lib:DRV8353HRTAT
- added C? (x4): (no value), symbol Device:C_Small
- added IC?: (no value), symbol custom_lib:DRV8320RHRHAT
Connections:
- new net CB: C?.2, IC?.35 (CB)
- new net CPH: C?.1, IC?.3 (CPH)
- new net CPL: C?.2, IC?.2 (CPL)
- new net GHA: IC?.7 (GHA)
- new net GHB: IC?.12 (GLB)
- new net GHC: IC?.15 (GHC)
- new net GLA: IC?.9 (GLA)
- new net GLC: IC?.17 (GLC)
- new net GLH: IC?.14 (GHB)
- new net GND: C?.2, IC?.1 (PGND), IC?.19 (GND)
- new net SHA: IC?.8 (SHA)
- new net SHB: IC?.13 (SHB)
- new net SHC: IC?.16 (SHC)
- new net SLA: IC?.10 (SLA)
- new net SLB: IC?.11 (SLB)
- new net SLC: IC?.18 (SLC)
- new net SW: C?.1, IC?.36 (SW)
- new net VCC: C?.1, C?.2, IC?.5 (VM)
- new net VCP: C?.1, IC?.4 (VCP)
- new net VDRAIN: IC?.6 (VDRAIN)

Commit message: Changed footprint and connections for some things
Parts:
- C? (x3), IC?: value (none) -> ~
Connections:
- net GND: now also IC?.26 (AGND), IC?.34 (BGND)
- net ENABLE: now reaches IC?.25 (ENABLE)
- net INHA: now reaches IC?.28 (INHA)
- net INLA: now reaches IC?.29 (INLA)
- net INHB: now reaches IC?.30 (INHB)
- net INLB: now reaches IC?.31 (INLB)
- net INHC: now reaches IC?.32 (INHC)
- net INLC: now reaches IC?.33 (INLC)
- no-connect marks 0 -> 2
Other:
- moved on the sheet: C?
Changed lines of the file:
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@@
 (kicad_sch (version 20211123) (generator eeschema)
   (paper "A4")
+  (junction (at 99.06 95.25) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 125.73 72.39) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 119.38 64.77) (diameter 0) (color 0 0 0 0)
   )
-  (wire (pts (xy 153.67 36.83) (xy 154.94 36.83))
+  (no_connect (at 149.86 54.61))
+  (no_connect (at 172.72 87.63))
+  (wire (pts (xy 95.25 57.15) (xy 100.33 57.15))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 162.56 46.99) (xy 162.56 54.61))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 180.34 74.93) (xy 172.72 74.93))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 157.48 54.61) (xy 157.48 46.99))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 142.24 120.65) (xy 142.24 113.03))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 180.34 72.39) (xy 172.72 72.39))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 95.25 71.12) (xy 100.33 71.12))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 180.34 77.47) (xy 172.72 77.47))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 124.46 95.25) (xy 132.08 95.25))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 83.82 57.15) (xy 90.17 57.15))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 152.4 46.99) (xy 152.4 54.61))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 99.06 95.25) (xy 99.06 97.79))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 119.38 64.77) (xy 119.38 82.55))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 90.17 90.17) (xy 99.06 90.17))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 172.72 82.55) (xy 180.34 82.55))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 125.73 72.39) (xy 125.73 102.87))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 165.1 46.99) (xy 165.1 54.61))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 99.06 90.17) (xy 99.06 95.25))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 180.34 85.09) (xy 172.72 85.09))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 95.25 80.01) (xy 100.33 80.01))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 146.05 36.83) (xy 148.59 36.83))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
   (wire (pts (xy 147.32 120.65) (xy 147.32 113.03))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 160.02 46.99) (xy 160.02 54.61))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 154.94 120.65) (xy 154.94 113.03))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 90.17 95.25) (xy 99.06 95.25))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 124.46 92.71) (xy 132.08 92.71))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
   (wire (pts (xy 157.48 113.03) (xy 157.48 120.65))
     (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (label "BGND" (at 90.17 95.25 180)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
+  (label "AGND" (at 90.17 90.17 180)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
   )
   (label "VM" (at 100.33 80.01 0)
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
-  (label "SW" (at 146.05 36.83 180)
-    (effects (font (size 1.27 1.27)) (justify right bottom))
+  (label "SW" (at 83.82 57.15 180)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
+  (label "AGND" (at 180.34 82.55 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
   )
   (label "VCP" (at 124.46 80.01 180)
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
-  (label "CB" (at 154.94 36.83 0)
+  (label "CB" (at 100.33 57.15 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
+  (label "BGND" (at 157.48 46.99 90)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
   (label "SLB" (at 139.7 120.65 270)
     (effects (font (size 1.27 1.27)) (justify right bottom))
@@
   (label "CB" (at 154.94 46.99 270)
     (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
+  (hierarchical_label "INHC" (shape input) (at 162.56 46.99 90)
+    (effects (font (size 1.27 1.27)) (justify left))
+  )
+  (hierarchical_label "INHA" (shape input) (at 180.34 77.47 0)
+    (effects (font (size 1.27 1.27)) (justify left))
+  )
+  (hierarchical_label "INLB" (shape input) (at 165.1 46.99 90)
+    (effects (font (size 1.27 1.27)) (justify left))
+  )
+  (hierarchical_label "INHB" (shape input) (at 180.34 72.39 0)
+    (effects (font (size 1.27 1.27)) (justify left))
+  )
+  (hierarchical_label "ENABLE" (shape input) (at 180.34 85.09 0)
+    (effects (font (size 1.27 1.27)) (justify left))
+  )
+  (hierarchical_label "INLC" (shape input) (at 160.02 46.99 90)
+    (effects (font (size 1.27 1.27)) (justify left))
+  )
+  (hierarchical_label "INLA" (shape input) (at 180.34 74.93 0)
+    (effects (font (size 1.27 1.27)) (justify left))
   )
   (symbol (lib_id "power:VCC") (at 119.38 63.5 0) (unit 1)
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Value" "" (id 1) (at 119.38 59.9242 0))
+    (property "Value" "~" (id 1) (at 119.38 59.9242 0))
     (property "Footprint" "" (id 2) (at 119.38 63.5 0)
       (effects (font (size 1.27 1.27)) hide)
@@
     (pin "1")
   )
-  (symbol (lib_id "Device:C_Small") (at 151.13 36.83 90) (unit 1)
+  (symbol (lib_id "power:GND") (at 99.06 97.79 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR?" (id 0) (at 99.06 104.14 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (id 1) (at 99.06 102.2334 0))
+    (property "Footprint" "" (id 2) (at 99.06 97.79 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 99.06 97.79 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
+  (symbol (lib_id "Device:C_Small") (at 92.71 57.15 90) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "C?" (id 0) (at 149.86 33.02 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "" (id 1) (at 152.4 34.29 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "" (id 2) (at 151.13 36.83 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 151.13 36.83 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Material" "X7R" (id 4) (at 151.13 36.83 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Voltage" "16V" (id 5) (at 151.13 36.83 0)
+    (property "Reference" "C?" (id 0) (at 91.44 53.34 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "" (id 1) (at 93.98 54.61 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "" (id 2) (at 92.71 57.15 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 92.71 57.15 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Material" "X7R" (id 4) (at 92.71 57.15 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Voltage" "16V" (id 5) (at 92.71 57.15 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (id 1) (at 93.98 68.58 90)
+    (property "Value" "~" (id 1) (at 93.98 68.58 90)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
     (in_bom yes) (on_board yes) (fields_autoplaced)
     (property "Reference" "IC?" (id 0) (at 176.2925 66.6835 0))
-    (property "Value" "" (id 1) (at 176.2925 69.2204 0))
+    (property "Value" "~" (id 1) (at 176.2925 69.2204 0))
     (property "Footprint" "" (id 2) (at 168.91 59.69 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (id 1) (at 128.27 69.85 0)
+    (property "Value" "~" (id 1) (at 128.27 69.85 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Value" "GND" (id 1) (at 160.02 125.0934 0))
+    (property "Value" "" (id 1) (at 160.02 125.0934 0))
     (property "Footprint" "" (id 2) (at 160.02 120.65 0)
       (effects (font (size 1.27 1.27)) hide)
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (id 1) (at 93.98 77.47 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
+    (property "Value" "~" (id 1) (at 93.98 77.47 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )

Commit message: Updated localization files
Parts:
- added C? (x5), C_bypass? (x3): ~, symbol Device:C_Small
- added C? (x2): C, symbol Device:C
- added J?: Conn_01x03, symbol Connector_Generic:Conn_01x03
- added JP? (x3): SolderJumper_3_Open, symbol Jumper:SolderJumper_3_Open
- added Q? (x6): Q_NMOS_DGS, symbol Device:Q_NMOS_DGS
- added R? (x3): R_Small, symbol Device:R_Small
- added R? (x11): R, symbol Device:R
- added R? (x3): R, symbol Device:R_Small
- added TH?: Thermistor_NTC, symbol Device:Thermistor_NTC
- added TP?: TestPoint, symbol Connector:TestPoint
- added U? (x3): INA240A1D, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, symbol Amplifier_Current:INA240A1D
- C?: value (none) -> ~
Connections:
- net GND is gone; now on net +5V: C?.2, IC?.1 (PGND), IC?.19 (GND), IC?.26 (AGND), IC?.34 (BGND)
- net SLA is gone; now on net +5V: IC?.10 (SLA)
- net SLB is gone; now on net +5V: IC?.11 (SLB)
- net SLC is gone; now on net +5V: IC?.18 (SLC)
- net INHA: now also R?.1
- net INHB: now also R?.1
- net INHC: now also R?.1
- net INLA: now also R?.1
- net INLB: now also R?.1
- net INLC: now also R?.1
- net VCC: now also C?.1, R?.1, R?.1
- net at IC?.20 (NFAULT): now also R?.2, TP?.1
- net MODE: now reaches IC?.21 (MODE)
- net MODE: now also R?.2
- net IDRIVE: now reaches IC?.22 (IDRIVE)
- net IDRIVE: now also R?.2
- net VDS: now reaches IC?.23 (VDS)
- net VDS: now also R?.2
- net +3.3VP: now reaches IC?.27 (DVDD)
- net +3.3VP: now also C?.1, JP?.1 (A), JP?.1 (A), JP?.1 (A)
- net Vdrive: now reaches IC?.38 (VIN)
- net Vdrive: now also C?.1, C_bypass?.2, C_bypass?.2, C_bypass?.2, Q?.1 (D), Q?.1 (D), Q?.1 (D), R?.1
- net at IC?.39 (NSHDN): now also R?.2
- net FB: now reaches IC?.40 (FB)
- net FB: now also R?.1, R?.2
- net +5V: now reaches IC?.41 (EP)
- net +5V: now also C?.1, C?.1, C?.1, C?.2, C?.2, C?.2, C?.2, C?.2, C?.2, C_bypass?.1, C_bypass?.1, C_bypass?.1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
- net GLH renamed GLB
- net SHA renamed SAP
- net SAP: now also Q?.1 (D), Q?.3 (S), R?.1, U?.8 (+)
- net SHB renamed SBP
- net SBP: now also Q?.1 (D), Q?.3 (S), R?.1, U?.8 (+)
- net SHC renamed SCP
- net SCP: now also Q?.1 (D), Q?.3 (S), R?.1, U?.8 (+)
- new net: Q?.2 (G), R?.2 (x6)
- new net: JP?.2 (C), R?.1 (x3)
- new net BLDC_PH1_S: U?.5
- new net BLDC_PH2_S: U?.5
- new net BLDC_PH3_S: U?.5
- new net GNDA: C?.2, R?.2
- new net SAN: J?.1 (Pin_1), R?.2, U?.1 (-)
- new net SBN: J?.2 (Pin_2), R?.2, U?.1 (-)
- new net SCN: J?.3 (Pin_3), R?.2, U?.1 (-)
- new net TEMP_BLDC: C?.1, R?.1, TH?.2
- new net VDDA: TH?.1
Other:
- note added: "IDRIVE controls the output gate current of the DRV chip. Here, IDRIVE = HI-Z, Idriven = 240 ma (check [1] for more info)"
- note added: "INA240 was designed to have a good PWM common mode rejection. Given that this is the shape of the common mode signal going through each phase, this is ideal."
- note added: "SxP and SxN should be routed as differential pairs for more accurate measurements"
- moved on the sheet: C?, IC?

Commit message: Updated localization files
Other:
- moved on the sheet: C?, U?
